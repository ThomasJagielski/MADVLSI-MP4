v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -370 170 -320 170 { lab=Vbn}
N -60 90 -50 90 { lab=s2}
N -50 90 -50 180 { lab=s2}
N -160 90 -150 90 { lab=s1}
N -150 90 -150 180 { lab=s1}
N -260 90 -250 90 { lab=s0}
N -250 90 -250 180 { lab=s0}
N -250 -200 -120 -200 { lab=Vb1}
N -410 -290 -220 -290 { lab=Vg}
N -220 -290 -30 -290 { lab=Vg}
N -60 -200 0 -200 { lab=Vb2}
N -280 -290 -280 -230 { lab=Vg}
N -90 -290 -90 -230 { lab=Vg}
N -380 -200 -310 -200 { lab=Vb0}
N -320 170 -220 170 { lab=Vbn}
N -220 170 -120 170 { lab=Vbn}
N -100 -90 -100 50 { lab=b2}
N -230 -90 -230 50 { lab=b1}
N -230 50 -200 50 { lab=b1}
N -410 50 -300 50 { lab=b0}
N -500 -290 -410 -290 { lab=Vg}
N -410 -90 -410 -60 { lab=b0}
N -320 130 -320 170 { lab=Vbn}
N -370 130 -360 130 { lab=Vbp}
N -220 130 -220 170 { lab=Vbn}
N -120 130 -120 170 { lab=Vbn}
N -410 -60 -410 50 { lab=b0}
N -100 -90 -30 -90 { lab=b2}
N -230 -90 -220 -90 { lab=b1}
N -490 150 -470 150 { lab=#net1}
N -380 -200 -380 -130 { lab=Vb0}
N -190 -200 -190 -130 { lab=Vb1}
N 0 -200 -0 -130 { lab=Vb2}
N -320 170 -320 440 { lab=Vbn}
N -320 440 -260 440 { lab=Vbn}
N 100 330 120 330 { lab=#net2}
N 100 140 120 140 { lab=Vbp}
N 100 240 120 240 { lab=#net2}
N 100 190 100 240 { lab=#net2}
N 100 190 150 190 { lab=#net2}
N 150 190 150 210 { lab=#net2}
N 150 170 150 190 { lab=#net2}
N 150 290 150 300 { lab=#net3}
N 250 170 250 210 { lab=Vg}
N 220 190 220 240 { lab=Vg}
N 220 190 250 190 { lab=Vg}
N 120 140 220 140 { lab=Vbp}
N 220 240 360 240 { lab=Vg}
N 390 290 390 300 { lab=#net4}
N 390 270 390 280 { lab=#net4}
N 390 280 390 290 { lab=#net4}
N 250 270 250 280 { lab=#net5}
N 150 280 250 280 { lab=#net5}
N 150 270 150 280 { lab=#net5}
N 100 240 100 330 { lab=#net2}
N 390 170 390 200 { lab=#net6}
N 220 140 360 140 { lab=Vbp}
N -350 -350 -330 -350 { lab=Vdr1}
N -330 -350 -330 -320 { lab=Vdr1}
N -380 -320 -330 -320 { lab=Vdr1}
N -240 -350 -220 -350 { lab=Vdr2}
N -240 -350 -240 -320 { lab=Vdr2}
N -240 -320 -190 -320 { lab=Vdr2}
N -0 -250 -0 -200 { lab=Vb2}
N -190 -250 -190 -200 { lab=Vb1}
N -380 -250 -380 -200 { lab=Vb0}
N 460 -440 460 -380 { lab=Vg}
N 380 -350 380 -320 { lab=#net7}
N 380 -350 430 -350 { lab=#net7}
N 490 -350 550 -350 { lab=#net8}
N 550 -410 550 -350 { lab=#net8}
N 380 -410 380 -350 { lab=#net7}
N 460 -440 520 -440 { lab=Vg}
N 380 -590 380 -470 { lab=#net9}
N 550 -500 550 -470 { lab=#net10}
N 430 -690 430 -660 { lab=Vbout}
N 430 -690 460 -690 { lab=Vbout}
N 460 -730 460 -690 { lab=Vbout}
N 320 -440 460 -440 { lab=Vg}
N 320 -900 320 -880 { lab=Vdr3}
N 460 -910 460 -880 { lab=#net11}
N 460 -910 620 -910 { lab=#net11}
N 620 -910 620 -880 { lab=#net11}
N 390 -850 430 -850 { lab=#net9}
N 390 -850 390 -800 { lab=#net9}
N 320 -800 390 -800 { lab=#net9}
N 320 -820 320 -800 { lab=#net9}
N 460 -820 460 -740 { lab=#net12}
N 620 -800 620 -500 { lab=#net10}
N 200 -900 320 -900 { lab=Vdr3}
N 320 -800 320 -590 { lab=#net9}
N 650 -850 670 -850 { lab=#net10}
N 670 -960 670 -850 { lab=#net10}
N 350 -960 670 -960 { lab=#net10}
N 670 -850 670 -800 { lab=#net10}
N 620 -800 670 -800 { lab=#net10}
N 460 -930 460 -910 { lab=#net11}
N 350 -850 390 -850 { lab=#net9}
N 320 -930 320 -900 { lab=Vdr3}
N 620 -820 620 -800 { lab=#net10}
N 320 -590 380 -590 { lab=#net9}
N 550 -500 620 -500 { lab=#net10}
N 380 -320 380 -260 { lab=#net7}
N -30 -360 -30 -330 { lab=Vdr3}
N -30 -330 0 -330 { lab=Vdr3}
N 560 140 680 140 { lab=Vdr3}
N 560 240 580 240 { lab=#net13}
N 560 190 560 240 { lab=#net13}
N 560 190 610 190 { lab=#net13}
N 610 190 610 210 { lab=#net13}
N 610 170 610 190 { lab=#net13}
N 610 290 610 300 { lab=#net14}
N 710 190 710 210 { lab=Vgo}
N 680 190 680 240 { lab=Vgo}
N 680 190 710 190 { lab=Vgo}
N 680 240 820 240 { lab=Vgo}
N 710 270 710 280 { lab=#net15}
N 610 280 710 280 { lab=#net15}
N 610 270 610 280 { lab=#net15}
N 560 240 560 330 { lab=#net13}
N 710 170 710 190 { lab=Vgo}
N 560 330 580 330 { lab=#net13}
N -800 -250 -800 -190 { lab=GND}
N -640 -250 -640 -190 { lab=GND}
N -800 -340 -800 -310 { lab=#net16}
N -720 -410 -670 -410 { lab=#net16}
N -720 -410 -720 -340 { lab=#net16}
N -800 -340 -720 -340 { lab=#net16}
N -770 -410 -720 -410 { lab=#net16}
N -800 -380 -800 -340 { lab=#net16}
N -640 -380 -640 -310 { lab=Vgt}
N -260 400 -230 400 { lab=Vbd}
N -260 310 -260 340 { lab=#net17}
N -260 340 -230 340 { lab=#net17}
N 380 -140 510 -140 { lab=#net18}
N 510 -260 650 -260 { lab=#net19}
N 650 -140 790 -140 { lab=#net20}
N -30 -900 -30 -360 { lab=Vdr3}
N -30 -900 200 -900 { lab=Vdr3}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} -300 90 3 0 {name=X2}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} -200 90 3 0 {name=X3}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} -100 90 3 0 {name=X4}
C {madvlsi/gnd.sym} -280 130 0 0 {name=l1 lab=GND}
C {madvlsi/gnd.sym} -180 130 0 0 {name=l2 lab=GND}
C {madvlsi/gnd.sym} -80 130 0 0 {name=l3 lab=GND}
C {madvlsi/resistor.sym} -500 180 0 0 {name=R1
value=100k
m=1}
C {madvlsi/gnd.sym} -500 210 0 0 {name=l8 lab=GND}
C {madvlsi/vsource.sym} -570 180 0 0 {name=Vdd
value=1.8}
C {madvlsi/vdd.sym} -570 150 0 0 {name=l9 lab=VDD}
C {madvlsi/gnd.sym} -570 210 0 0 {name=l10 lab=GND}
C {madvlsi/vsource.sym} -250 210 0 0 {name=Vb0
value=1.8
*"pwl 1n 0 2u 1.8 32u 1.8 33u 0 100u 0 "}
C {madvlsi/gnd.sym} -250 240 0 0 {name=l11 lab=GND}
C {madvlsi/vsource.sym} -150 210 0 0 {name=Vb1
value=1.8
*"pwl 32u 0 33u 1.8 63u 1.8 64u 0 100u 0"}
C {madvlsi/gnd.sym} -150 240 0 0 {name=l12 lab=GND}
C {madvlsi/vsource.sym} -50 210 0 0 {name=Vb2
value=1.8
*"pwl 63u 0 64u 1.8 94u 1.8 95u 0 100u 0"}
C {madvlsi/gnd.sym} -50 240 0 0 {name=l13 lab=GND}
C {madvlsi/nmos3.sym} -380 -290 0 0 {name=M9
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -280 -200 1 0 {name=M10
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -190 -290 0 0 {name=M11
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -90 -200 1 0 {name=M12
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 0 -290 0 0 {name=M13
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -380 -90 0 0 {name=M18
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -190 -90 0 0 {name=M19
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 0 -90 0 0 {name=M20
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} -380 -60 0 0 {name=l18 lab=GND}
C {madvlsi/gnd.sym} -190 -60 0 0 {name=l19 lab=GND}
C {madvlsi/gnd.sym} 0 -60 0 0 {name=l20 lab=GND}
C {madvlsi/vdd.sym} -190 -380 0 0 {name=l6 lab=VDD}
C {madvlsi/vdd.sym} -380 -380 0 0 {name=l7 lab=VDD}
C {madvlsi/tt_models.sym} -600 -40 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=1.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {madvlsi/ammeter1.sym} 0 -330 0 0 {name=Vmeas}
C {devices/lab_pin.sym} -340 50 1 0 {name=l14 sig_type=std_logic lab=b0}
C {devices/lab_pin.sym} -230 10 2 0 {name=l15 sig_type=std_logic lab=b1}
C {devices/lab_pin.sym} -100 10 2 0 {name=l16 sig_type=std_logic lab=b2}
C {devices/lab_pin.sym} -310 170 3 0 {name=l17 sig_type=std_logic lab=Vbn}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/ibias.sym} -420 150 0 0 {name=X1}
C {devices/lab_pin.sym} -250 90 1 0 {name=l21 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} -150 90 1 0 {name=l22 sig_type=std_logic lab=s1}
C {devices/lab_pin.sym} -50 90 1 0 {name=l23 sig_type=std_logic lab=s2}
C {madvlsi/ammeter1.sym} -490 150 1 1 {name=Vbias}
C {madvlsi/ammeter1.sym} -380 -130 0 0 {name=VIb0}
C {madvlsi/ammeter1.sym} -190 -130 0 0 {name=VIb1}
C {madvlsi/ammeter1.sym} 0 -130 0 0 {name=VIb2}
C {madvlsi/pmos3.sym} 150 140 0 0 {name=M3
L=3
W=10
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 150 240 0 0 {name=M4
L=1
W=3
body=GND
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 150 330 0 0 {name=M5
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 150 360 0 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} 360 330 0 0 {name=l27 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 100 140 0 0 {name=l28 sig_type=std_logic lab=Vbp}
C {madvlsi/ammeter1.sym} 150 280 0 0 {name=Vim}
C {madvlsi/nmos3.sym} 250 240 0 0 {name=M6
L=1
W=3
body=GND
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 250 140 0 0 {name=M7
L=1
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 150 110 0 0 {name=l29 lab=VDD}
C {madvlsi/vdd.sym} 250 110 0 0 {name=l30 lab=VDD}
C {madvlsi/nmos3.sym} 390 240 0 0 {name=M8
L=1
W=3
body=GND
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 390 110 0 0 {name=l31 lab=VDD}
C {madvlsi/nmos3.sym} 390 330 0 0 {name=M14
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/ammeter1.sym} 390 200 0 0 {name=Vim1}
C {madvlsi/gnd.sym} 390 360 0 0 {name=l32 lab=GND}
C {madvlsi/pmos3.sym} 390 140 0 0 {name=M15
L=1
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -360 130 1 0 {name=l4 sig_type=std_logic lab=Vbp}
C {devices/lab_pin.sym} 310 240 1 0 {name=l33 sig_type=std_logic lab=Vg}
C {devices/lab_pin.sym} -500 -290 1 0 {name=l34 sig_type=std_logic lab=Vg}
C {madvlsi/pmos3.sym} -190 -350 0 0 {name=M17
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -380 -350 0 1 {name=M21
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -380 -180 2 0 {name=l57 sig_type=std_logic lab=Vb0}
C {devices/lab_pin.sym} -190 -180 2 0 {name=l58 sig_type=std_logic lab=Vb1}
C {devices/lab_pin.sym} 0 -180 2 0 {name=l59 sig_type=std_logic lab=Vb2}
C {devices/lab_pin.sym} -330 -320 2 0 {name=l37 sig_type=std_logic lab=Vdr1}
C {devices/lab_pin.sym} -190 -320 2 0 {name=l38 sig_type=std_logic lab=Vdr2}
C {madvlsi/ammeter1.sym} -380 -260 0 0 {name=VIb4}
C {madvlsi/ammeter1.sym} -190 -260 0 0 {name=VIb5}
C {madvlsi/ammeter1.sym} 0 -260 0 0 {name=VIb6}
C {devices/code.sym} 70 -70 0 0 {name=SPICE only_toplevel=false value=".param Iref=100u
.control
  set wr_singlescale
  let runs = 10
  let run = 1
  while run <= runs
    set appendwrite = FALSE
    set wr_vecnames
    let code = 0
    while code < 8
      if code eq 0
        let b0 = 0
      else
        let b0 = (code % 2) * 1.8
      end
      if floor(code / 2) eq 0
        let b1 = 0
      else
        let b1 = (floor(code / 2) % 2) * 1.8
      end
      if floor(code / 4) eq 0
        let b2 = 0
      else
        let b2 = (floor(code / 4) % 2) * 1.8
      end
      alter vb0 $&b0
      alter vb1 $&b1
      alter vb2 $&b2
      save all
      op
      wrdata ~/Documents/MADVLSI-MP4/schematic/data/ladder3_og8thmcwilson-\{$&run\}.txt v(b0) v(b1) v(b2) i(vbias) i(viout) v(vbout)
      if code eq 0
        set appendwrite
        set wr_vecnames = FALSE
      end
      let code = code + 1
    end
    reset
    let run = run + 1
  end
.endc"}
C {madvlsi/ammeter1.sym} 460 -740 0 0 {name=VIout}
C {madvlsi/gnd.sym} 460 -630 0 0 {name=l40 lab=GND}
C {madvlsi/nmos3.sym} 460 -350 1 0 {name=M24
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 550 -440 0 0 {name=M25
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 380 -170 0 0 {name=M26
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 380 -440 0 0 {name=M27
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 320 -440 0 0 {name=l43 sig_type=std_logic lab=Vg}
C {madvlsi/nmos3.sym} 460 -660 0 0 {name=M16
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 460 -690 2 0 {name=l5 sig_type=std_logic lab=Vbout}
C {madvlsi/pmos3.sym} 320 -960 2 0 {name=M72
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 460 -960 2 0 {name=M73
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 320 -850 2 0 {name=M74
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 460 -850 0 0 {name=M75
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 620 -850 2 0 {name=M76
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 320 -990 0 0 {name=l53 lab=VDD}
C {madvlsi/vdd.sym} 460 -990 0 0 {name=l73 lab=VDD}
C {devices/lab_pin.sym} -30 -330 0 0 {name=l42 sig_type=std_logic lab=Vdr3}
C {madvlsi/pmos3.sym} 610 140 0 0 {name=M38
L=3
W=10
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 610 240 0 0 {name=M39
L=1
W=3
body=GND
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/ammeter1.sym} 610 280 0 0 {name=Vim2}
C {madvlsi/nmos3.sym} 710 240 0 0 {name=M41
L=1
W=3
body=GND
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 710 140 0 0 {name=M42
L=1
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 610 110 0 0 {name=l50 lab=VDD}
C {madvlsi/vdd.sym} 710 110 0 0 {name=l51 lab=VDD}
C {devices/lab_pin.sym} 820 240 2 0 {name=l49 sig_type=std_logic lab=Vgo}
C {madvlsi/nmos3.sym} 610 330 0 0 {name=M43
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 560 140 0 0 {name=l47 sig_type=std_logic lab=Vdr3}
C {madvlsi/gnd.sym} 610 360 0 0 {name=l76 lab=GND}
C {madvlsi/pmos3.sym} -800 -410 0 1 {name=M22
L=1.0
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -640 -410 0 0 {name=M58
L=1.0
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -800 -280 0 0 {name=M59
L=1.0
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -640 -280 0 1 {name=M60
L=1.0
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} -800 -440 0 0 {name=l65 lab=VDD}
C {madvlsi/vdd.sym} -640 -440 0 0 {name=l66 lab=VDD}
C {madvlsi/gnd.sym} -800 -190 0 0 {name=l67 lab=GND}
C {madvlsi/gnd.sym} -640 -190 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} -610 -280 2 0 {name=l69 sig_type=std_logic lab=Vbd}
C {devices/lab_pin.sym} -830 -280 0 0 {name=l70 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} -640 -340 2 0 {name=l71 sig_type=std_logic lab=Vgt}
C {madvlsi/nmos3.sym} -230 440 0 0 {name=M1
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/ammeter1.sym} -230 400 0 0 {name=VIb3}
C {madvlsi/gnd.sym} -230 470 0 0 {name=l25 lab=GND}
C {madvlsi/vdd.sym} -230 280 0 0 {name=l26 lab=VDD}
C {devices/lab_pin.sym} -260 400 0 0 {name=l63 sig_type=std_logic lab=Vbd}
C {madvlsi/nmos3.sym} -230 370 0 0 {name=M2
L=1
W=3
body=GND
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -260 370 0 0 {name=l64 sig_type=std_logic lab=Vgt}
C {madvlsi/pmos3.sym} -230 310 0 0 {name=M63
L=1
W=3
body=VDD
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 380 -230 0 0 {name=M23
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 350 -170 0 0 {name=l39 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 350 -230 0 0 {name=l44 sig_type=std_logic lab=Vbn}
C {madvlsi/nmos3.sym} 510 -170 0 0 {name=M28
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 510 -230 0 0 {name=M29
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 480 -170 0 0 {name=l48 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 480 -230 0 0 {name=l52 sig_type=std_logic lab=Vbn}
C {madvlsi/nmos3.sym} 650 -170 0 0 {name=M30
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 650 -230 0 0 {name=M31
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 620 -170 0 0 {name=l54 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 620 -230 0 0 {name=l55 sig_type=std_logic lab=Vbn}
C {madvlsi/nmos3.sym} 790 -170 0 0 {name=M32
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 790 -230 0 0 {name=M33
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 760 -170 0 0 {name=l60 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 760 -230 0 0 {name=l61 sig_type=std_logic lab=Vbn}
C {madvlsi/gnd.sym} 790 -260 2 0 {name=l62 lab=GND}
