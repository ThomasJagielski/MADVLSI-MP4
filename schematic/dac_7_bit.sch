v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 0 90 10 90 { lab=s2}
N 10 90 10 180 { lab=s2}
N -190 90 -180 90 { lab=s1}
N -180 90 -180 180 { lab=s1}
N -380 90 -370 90 { lab=s0}
N -370 90 -370 180 { lab=s0}
N -250 -200 -120 -200 { lab=Vb1}
N -60 -200 0 -200 { lab=Vb2}
N -280 -290 -280 -230 { lab=Vg}
N -90 -290 -90 -230 { lab=Vg}
N -380 -200 -310 -200 { lab=Vb0}
N -40 -90 -40 50 { lab=b2}
N -230 -90 -230 50 { lab=b1}
N -500 -290 -410 -290 { lab=Vg}
N -440 130 -440 170 { lab=Vbn}
N -250 130 -250 170 { lab=Vbn}
N -60 130 -60 170 { lab=Vbn}
N -230 -90 -220 -90 { lab=b1}
N -660 150 -640 150 { lab=#net1}
N -380 -200 -380 -130 { lab=Vb0}
N -190 -200 -190 -130 { lab=Vb1}
N 0 -200 -0 -130 { lab=Vb2}
N -780 -200 -760 -200 { lab=#net2}
N -780 -390 -760 -390 { lab=Vbp}
N -780 -290 -760 -290 { lab=#net2}
N -780 -340 -780 -290 { lab=#net2}
N -780 -340 -730 -340 { lab=#net2}
N -730 -340 -730 -320 { lab=#net2}
N -730 -360 -730 -340 { lab=#net2}
N -730 -240 -730 -230 { lab=#net3}
N -630 -360 -630 -320 { lab=Vg}
N -760 -390 -660 -390 { lab=Vbp}
N -630 -260 -630 -250 { lab=#net4}
N -730 -250 -630 -250 { lab=#net4}
N -730 -260 -730 -250 { lab=#net4}
N -780 -290 -780 -200 { lab=#net2}
N -0 -250 -0 -200 { lab=Vb2}
N -190 -250 -190 -200 { lab=Vb1}
N -380 -250 -380 -200 { lab=Vb0}
N -600 -320 -600 -290 { lab=Vg}
N -630 -320 -600 -320 { lab=Vg}
N -600 -290 -570 -290 { lab=Vg}
N 190 90 200 90 { lab=s3}
N 380 90 390 90 { lab=s4}
N 570 90 580 90 { lab=s5}
N 770 90 780 90 { lab=s6}
N 710 130 710 170 { lab=Vbn}
N 510 130 510 170 { lab=Vbn}
N 320 130 320 170 { lab=Vbn}
N 130 130 130 170 { lab=Vbn}
N 200 90 200 180 { lab=s3}
N 390 90 390 180 { lab=s4}
N 580 90 580 180 { lab=s5}
N 780 90 780 180 { lab=s6}
N -380 -330 -380 -320 { lab=#net5}
N -190 -330 -190 -320 { lab=#net6}
N -420 -90 -410 -90 { lab=b0}
N -420 -90 -420 50 { lab=b0}
N -40 -90 -30 -90 { lab=b2}
N -540 170 -440 170 { lab=Vbn}
N -220 -360 -220 -330 { lab=#net6}
N -220 -330 -190 -330 { lab=#net6}
N -410 -360 -410 -330 { lab=#net5}
N -410 -330 -380 -330 { lab=#net5}
N 150 -90 160 -90 { lab=b3}
N 340 -90 350 -90 { lab=b4}
N 530 -90 540 -90 { lab=b5}
N 730 -90 740 -90 { lab=b6}
N 730 -90 730 50 { lab=b6}
N 530 -90 530 50 { lab=b5}
N 340 -90 340 50 { lab=b4}
N 150 -90 150 50 { lab=b3}
N -440 170 710 170 { lab=Vbn}
N -0 -200 70 -200 { lab=Vb2}
N 130 -200 260 -200 { lab=#net7}
N 320 -200 450 -200 { lab=#net8}
N 510 -200 650 -200 { lab=#net9}
N 770 -260 770 -120 { lab=#net10}
N 570 -260 570 -200 { lab=#net9}
N 570 -200 570 -120 { lab=#net9}
N 380 -260 380 -200 { lab=#net8}
N 380 -200 380 -120 { lab=#net8}
N 190 -200 190 -120 { lab=#net7}
N 190 -260 190 -200 { lab=#net7}
N -410 -290 740 -290 { lab=Vg}
N 100 -290 100 -230 { lab=Vg}
N 290 -290 290 -230 { lab=Vg}
N 480 -290 480 -230 { lab=Vg}
N 680 -290 680 -230 { lab=Vg}
N 710 -200 770 -200 { lab=#net10}
N -30 -360 -30 -330 { lab=#net11}
N -30 -330 -0 -330 { lab=#net11}
N 570 -330 570 -320 { lab=#net12}
N 380 -330 380 -320 { lab=#net13}
N 190 -330 190 -320 { lab=#net14}
N 160 -360 160 -330 { lab=#net14}
N 160 -330 190 -330 { lab=#net14}
N 350 -360 350 -330 { lab=#net13}
N 350 -330 380 -330 { lab=#net13}
N 540 -360 540 -330 { lab=#net12}
N 540 -330 570 -330 { lab=#net12}
N 1120 -130 1160 -130 { lab=Vbn}
N 990 -160 1080 -160 { lab=#net15}
N 1020 -130 1120 -130 { lab=Vbn}
N 1190 -280 1190 -160 { lab=#net16}
N 770 -360 770 -330 { lab=#net17}
N 770 -360 1190 -360 { lab=#net17}
N 990 -320 990 -160 { lab=#net15}
N 990 -320 1190 -320 { lab=#net15}
N 1310 -320 1350 -320 { lab=Vout}
N 1140 -160 1140 -130 { lab=Vbn}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} -420 90 3 0 {name=X2}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} -230 90 3 0 {name=X3}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} -40 90 3 0 {name=X4}
C {madvlsi/gnd.sym} -400 130 0 0 {name=l1 lab=GND}
C {madvlsi/gnd.sym} -210 130 0 0 {name=l2 lab=GND}
C {madvlsi/gnd.sym} -20 130 0 0 {name=l3 lab=GND}
C {madvlsi/resistor.sym} -670 180 0 0 {name=R1
value=100k
m=1}
C {madvlsi/gnd.sym} -670 210 0 0 {name=l8 lab=GND}
C {madvlsi/vsource.sym} -740 180 0 0 {name=Vdd
value=1.8}
C {madvlsi/vdd.sym} -740 150 0 0 {name=l9 lab=VDD}
C {madvlsi/gnd.sym} -740 210 0 0 {name=l10 lab=GND}
C {madvlsi/vsource.sym} -370 210 0 0 {name=Vb0
value=0
}
C {madvlsi/gnd.sym} -370 240 0 0 {name=l11 lab=GND}
C {madvlsi/vsource.sym} -180 210 0 0 {name=Vb1
value=0}
C {madvlsi/gnd.sym} -180 240 0 0 {name=l12 lab=GND}
C {madvlsi/vsource.sym} 10 210 0 0 {name=Vb2
value=0}
C {madvlsi/gnd.sym} 10 240 0 0 {name=l13 lab=GND}
C {madvlsi/nmos3.sym} -380 -290 0 0 {name=M9
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -280 -200 1 0 {name=M10
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -190 -290 0 0 {name=M11
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -90 -200 1 0 {name=M12
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 0 -290 0 0 {name=M13
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -380 -90 0 0 {name=M18
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -190 -90 0 0 {name=M19
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 0 -90 0 0 {name=M20
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} -380 -60 0 0 {name=l18 lab=GND}
C {madvlsi/gnd.sym} -190 -60 0 0 {name=l19 lab=GND}
C {madvlsi/gnd.sym} 0 -60 0 0 {name=l20 lab=GND}
C {madvlsi/vdd.sym} 0 -390 0 0 {name=l5 lab=VDD}
C {madvlsi/vdd.sym} -190 -380 0 0 {name=l6 lab=VDD}
C {madvlsi/vdd.sym} -380 -380 0 0 {name=l7 lab=VDD}
C {madvlsi/tt_models.sym} -760 -40 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {devices/code_shown.sym} 410 -730 0 0 {name=SPICE only_toplevel=false value=".control
tran 0.01u 100u
run
plot tran1.i(Vmeas) tran1.i(Vbias) tran1.i(VIb3) tran1.i(VIout)
plot tran1.i(Vib0) tran1.i(Vib1) tran1.i(Vib2) 
*plot tran1.v(b0) tran1.v(b1) tran1.v(b2) tran1.v(vbn) tran1.v(vbp) 
plot tran1.v(Vdr1) tran1.v(Vdr2) tran1.v(Vdr3)
plot tran1.i(Vib4) tran1.i(Vib5) tran1.i(Vib6)
*plot tran1.v(s0) tran1.v(s1) tran1.v(s2) 
*plot tran1.v(Vdr1) tran1.v(Vdr2) tran1.v(Vdr3) tran1.v(Vdr4) tran1.v(Vdr5)
reset
*dc Vdd 0 1.8 0.01
*plot dc.i(Vmeas) dc.i(Vbias) dc.i(VIb3) dc.i(VIout)
*plot dc.v(Vdr3) dc.v(Vbout)
.endc
.save all"}
C {madvlsi/ammeter1.sym} 770 -330 0 0 {name=VIout
}
C {devices/lab_pin.sym} -40 -90 0 0 {name=l16 sig_type=std_logic lab=b2}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/ibias.sym} -590 150 0 0 {name=X1}
C {devices/lab_pin.sym} -370 90 1 0 {name=l21 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} -180 90 1 0 {name=l22 sig_type=std_logic lab=s1}
C {devices/lab_pin.sym} 10 90 1 0 {name=l23 sig_type=std_logic lab=s2}
C {madvlsi/ammeter1.sym} -660 150 1 1 {name=Vbias}
C {madvlsi/ammeter1.sym} -380 -130 0 0 {name=VIb0}
C {madvlsi/ammeter1.sym} -190 -130 0 0 {name=VIb1}
C {madvlsi/ammeter1.sym} 0 -130 0 0 {name=VIb2}
C {madvlsi/pmos3.sym} -730 -390 0 0 {name=M3
L=3
W=10
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -730 -290 0 0 {name=M4
L=1
W=3
body=GND
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -730 -200 0 0 {name=M5
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} -730 -170 0 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} -780 -390 0 0 {name=l28 sig_type=std_logic lab=Vbp}
C {madvlsi/ammeter1.sym} -730 -250 0 0 {name=Vim}
C {madvlsi/nmos3.sym} -630 -290 2 0 {name=M6
L=1
W=3
body=GND
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -630 -390 0 0 {name=M7
L=1
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} -730 -420 0 0 {name=l29 lab=VDD}
C {madvlsi/vdd.sym} -630 -420 0 0 {name=l30 lab=VDD}
C {devices/lab_pin.sym} -540 130 2 0 {name=l4 sig_type=std_logic lab=Vbp}
C {devices/lab_pin.sym} -570 -290 1 0 {name=l33 sig_type=std_logic lab=Vg}
C {devices/lab_pin.sym} -500 -290 1 0 {name=l34 sig_type=std_logic lab=Vg}
C {madvlsi/pmos3.sym} 0 -360 0 0 {name=M16
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -190 -360 0 0 {name=M17
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -380 -360 2 1 {name=M21
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -380 -180 2 0 {name=l57 sig_type=std_logic lab=Vb0}
C {devices/lab_pin.sym} -190 -180 2 0 {name=l58 sig_type=std_logic lab=Vb1}
C {devices/lab_pin.sym} 0 -180 2 0 {name=l59 sig_type=std_logic lab=Vb2}
C {madvlsi/ammeter1.sym} -380 -260 0 0 {name=VIb4}
C {madvlsi/ammeter1.sym} -190 -260 0 0 {name=VIb5}
C {madvlsi/ammeter1.sym} 0 -260 0 0 {name=VIb6}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 150 90 3 0 {name=X5}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 340 90 3 0 {name=X6}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 530 90 3 0 {name=X7}
C {devices/lab_pin.sym} 200 90 1 0 {name=l25 sig_type=std_logic lab=s3}
C {devices/lab_pin.sym} 390 90 1 0 {name=l26 sig_type=std_logic lab=s4}
C {devices/lab_pin.sym} 580 90 1 0 {name=l27 sig_type=std_logic lab=s5}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 730 90 3 0 {name=X8}
C {devices/lab_pin.sym} 780 90 1 0 {name=l31 sig_type=std_logic lab=s6}
C {madvlsi/vsource.sym} 200 210 0 0 {name=Vb3
value=0
}
C {madvlsi/vsource.sym} 390 210 0 0 {name=Vb4
value=0}
C {madvlsi/vsource.sym} 580 210 0 0 {name=Vb5
value=0}
C {madvlsi/vsource.sym} 780 210 0 0 {name=Vb6
value=0}
C {madvlsi/gnd.sym} 200 240 0 0 {name=l32 lab=GND}
C {madvlsi/gnd.sym} 390 240 0 0 {name=l35 lab=GND}
C {madvlsi/gnd.sym} 580 240 0 0 {name=l36 lab=GND}
C {madvlsi/gnd.sym} 780 240 0 0 {name=l40 lab=GND}
C {madvlsi/gnd.sym} 170 130 0 0 {name=l41 lab=GND}
C {madvlsi/gnd.sym} 360 130 0 0 {name=l42 lab=GND}
C {madvlsi/gnd.sym} 550 130 0 0 {name=l43 lab=GND}
C {madvlsi/gnd.sym} 750 130 0 0 {name=l44 lab=GND}
C {madvlsi/nmos3.sym} 190 -290 0 0 {name=M1
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 290 -200 1 0 {name=M2
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 380 -290 0 0 {name=M8
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 480 -200 1 0 {name=M14
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 570 -290 0 0 {name=M15
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 190 -90 0 0 {name=M22
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 380 -90 0 0 {name=M23
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 570 -90 0 0 {name=M24
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 570 -360 0 0 {name=M25
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 380 -360 0 0 {name=M26
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 190 -360 2 1 {name=M27
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -490 170 3 0 {name=l45 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} -420 -90 0 0 {name=l46 sig_type=std_logic lab=b0}
C {devices/lab_pin.sym} -230 -90 0 0 {name=l47 sig_type=std_logic lab=b1}
C {madvlsi/nmos3.sym} 680 -200 1 0 {name=M28
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 770 -290 0 0 {name=M29
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 770 -90 0 0 {name=M30
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 530 -90 0 0 {name=l15 sig_type=std_logic lab=b5}
C {devices/lab_pin.sym} 150 -90 0 0 {name=l17 sig_type=std_logic lab=b3}
C {devices/lab_pin.sym} 340 -90 0 0 {name=l37 sig_type=std_logic lab=b4}
C {devices/lab_pin.sym} 730 -90 0 0 {name=l48 sig_type=std_logic lab=b6}
C {madvlsi/nmos3.sym} 100 -200 1 0 {name=M32
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 190 -60 0 0 {name=l49 lab=GND}
C {madvlsi/gnd.sym} 380 -60 0 0 {name=l50 lab=GND}
C {madvlsi/gnd.sym} 570 -60 0 0 {name=l51 lab=GND}
C {madvlsi/gnd.sym} 770 -60 0 0 {name=l52 lab=GND}
C {madvlsi/vdd.sym} 570 -390 0 0 {name=l14 lab=VDD}
C {madvlsi/vdd.sym} 380 -390 0 0 {name=l38 lab=VDD}
C {madvlsi/vdd.sym} 190 -390 0 0 {name=l39 lab=VDD}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/low-voltage_super-wilson.sym} 1170 -260 0 0 {name=X9}
C {madvlsi/nmos3.sym} 990 -130 2 0 {name=M33
L=10
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1080 -130 2 0 {name=M34
L=10
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1080 -100 0 0 {name=l60 lab=GND}
C {madvlsi/nmos3.sym} 1190 -130 0 0 {name=M38
L=10
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1190 -100 0 0 {name=l61 lab=GND}
C {madvlsi/gnd.sym} 990 -100 0 0 {name=l62 lab=GND}
C {devices/lab_pin.sym} 1350 -320 2 0 {name=l53 sig_type=std_logic lab=Vout}
C {devices/lab_pin.sym} 1140 -160 1 0 {name=l54 sig_type=std_logic lab=Vbn}
