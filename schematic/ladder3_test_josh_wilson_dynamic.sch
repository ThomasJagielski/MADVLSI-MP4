v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -160 90 -150 90 { lab=s1}
N -150 90 -150 180 { lab=s1}
N -370 90 -360 90 { lab=s0}
N -360 90 -360 180 { lab=s0}
N -190 -200 -120 -200 { lab=Vb1}
N -280 -290 -90 -290 { lab=Vgt}
N 710 -290 770 -290 { lab=Vgt}
N 740 -200 800 -200 { lab=Vb6}
N -280 -290 -280 -230 { lab=Vgt}
N -380 -200 -310 -200 { lab=Vb0}
N -320 170 -220 170 { lab=Vbn}
N -220 170 -120 170 { lab=Vbn}
N -230 -90 -230 50 { lab=b1}
N -230 50 -200 50 { lab=b1}
N -500 -290 -280 -290 { lab=Vgt}
N -410 -90 -410 50 { lab=b0}
N -430 130 -430 170 { lab=Vbn}
N -220 130 -220 170 { lab=Vbn}
N -230 -90 -220 -90 { lab=b1}
N -380 -200 -380 -130 { lab=Vb0}
N -190 -200 -190 -130 { lab=Vb1}
N 800 -200 800 -130 { lab=Vb6}
N -430 170 -430 450 { lab=Vbn}
N -430 450 -370 450 { lab=Vbn}
N -370 410 -340 410 { lab=Vbd}
N 900 650 920 650 { lab=#net1}
N 900 460 1160 460 { lab=Vbp}
N 900 560 920 560 { lab=#net1}
N 900 510 900 560 { lab=#net1}
N 900 510 950 510 { lab=#net1}
N 950 510 950 530 { lab=#net1}
N 950 490 950 510 { lab=#net1}
N 950 610 950 620 { lab=#net2}
N 1050 510 1050 530 { lab=Vg}
N 1020 510 1020 560 { lab=Vg}
N 1020 510 1050 510 { lab=Vg}
N 1020 560 1160 560 { lab=Vg}
N 950 590 950 600 { lab=#net3}
N 900 560 900 650 { lab=#net1}
N -350 -350 -330 -350 { lab=Vdr1}
N -330 -350 -330 -320 { lab=Vdr1}
N -240 -350 -220 -350 { lab=Vdr2}
N -240 -350 -240 -320 { lab=Vdr2}
N 800 -250 800 -200 { lab=Vb6}
N -190 -250 -190 -200 { lab=Vb1}
N -380 -250 -380 -200 { lab=Vb0}
N 1270 -440 1270 -380 { lab=Vgo}
N 1190 -350 1190 -320 { lab=#net4}
N 1190 -350 1240 -350 { lab=#net4}
N 1300 -350 1360 -350 { lab=#net5}
N 1360 -410 1360 -350 { lab=#net5}
N 1190 -410 1190 -350 { lab=#net4}
N 1270 -440 1330 -440 { lab=Vgo}
N 1190 -590 1190 -470 { lab=#net6}
N 1360 -500 1360 -470 { lab=#net7}
N 1240 -690 1240 -660 { lab=Vbout}
N 1240 -690 1270 -690 { lab=Vbout}
N 1270 -730 1270 -690 { lab=Vbout}
N 870 -320 870 -290 { lab=Vbon}
N 870 -320 900 -320 { lab=Vbon}
N 770 -330 800 -330 { lab=Vdr6}
N 770 -360 870 -360 { lab=Vdr6}
N 1030 80 1150 80 { lab=Vdr6}
N 1030 180 1050 180 { lab=#net8}
N 1030 130 1030 180 { lab=#net8}
N 1030 130 1080 130 { lab=#net8}
N 1080 130 1080 150 { lab=#net8}
N 1080 110 1080 130 { lab=#net8}
N 1080 230 1080 240 { lab=#net9}
N 1180 130 1180 150 { lab=Vgo}
N 1150 130 1150 180 { lab=Vgo}
N 1150 130 1180 130 { lab=Vgo}
N 1150 180 1290 180 { lab=Vgo}
N 1180 210 1180 220 { lab=#net10}
N 1080 220 1180 220 { lab=#net10}
N 1080 210 1080 220 { lab=#net10}
N 1030 180 1030 270 { lab=#net8}
N 1020 560 1020 620 { lab=Vg}
N 990 650 1050 650 { lab=#net3}
N 990 600 990 650 { lab=#net3}
N 950 600 990 600 { lab=#net3}
N -880 110 -880 170 { lab=GND}
N -720 110 -720 170 { lab=GND}
N -880 20 -880 50 { lab=#net11}
N -800 -50 -750 -50 { lab=#net11}
N -800 -50 -800 20 { lab=#net11}
N -880 20 -800 20 { lab=#net11}
N -850 -50 -800 -50 { lab=#net11}
N -880 -20 -880 20 { lab=#net11}
N -720 -20 -720 50 { lab=Vgt}
N -380 -320 -330 -320 { lab=Vdr1}
N -240 -320 -190 -320 { lab=Vdr2}
N -370 320 -370 350 { lab=#net12}
N -370 350 -340 350 { lab=#net12}
N -250 -200 -190 -200 { lab=Vb1}
N 1050 490 1050 510 { lab=Vg}
N 1130 -440 1270 -440 { lab=Vgo}
N 1180 110 1180 130 { lab=Vgo}
N 1130 -900 1130 -880 { lab=Vod}
N 1270 -910 1270 -880 { lab=#net13}
N 1270 -910 1430 -910 { lab=#net13}
N 1430 -910 1430 -880 { lab=#net13}
N 1200 -850 1240 -850 { lab=#net6}
N 1200 -850 1200 -800 { lab=#net6}
N 1130 -800 1200 -800 { lab=#net6}
N 1130 -820 1130 -800 { lab=#net6}
N 1270 -820 1270 -740 { lab=#net14}
N 1430 -800 1430 -500 { lab=#net7}
N 1010 -900 1130 -900 { lab=Vod}
N 1010 -900 1010 -330 { lab=Vod}
N 1130 -800 1130 -590 { lab=#net6}
N 1460 -850 1480 -850 { lab=#net7}
N 1480 -960 1480 -850 { lab=#net7}
N 1160 -960 1480 -960 { lab=#net7}
N 1480 -850 1480 -800 { lab=#net7}
N 1430 -800 1480 -800 { lab=#net7}
N 1270 -930 1270 -910 { lab=#net13}
N 1160 -850 1200 -850 { lab=#net6}
N 1130 -930 1130 -900 { lab=Vod}
N 1430 -820 1430 -800 { lab=#net7}
N 1130 -590 1190 -590 { lab=#net6}
N 1360 -500 1430 -500 { lab=#net7}
N 1610 -360 1610 -300 { lab=#net15}
N 1770 -360 1770 -300 { lab=#net15}
N 1610 -450 1610 -420 { lab=#net16}
N 1690 -520 1740 -520 { lab=#net16}
N 1690 -520 1690 -450 { lab=#net16}
N 1610 -450 1690 -450 { lab=#net16}
N 1640 -520 1690 -520 { lab=#net16}
N 1610 -490 1610 -450 { lab=#net16}
N 1770 -490 1770 -420 { lab=Vgot}
N 1610 -300 1770 -300 { lab=#net15}
N 1030 270 1050 270 { lab=#net8}
N 1190 -320 1190 -260 { lab=#net4}
N 870 -290 980 -290 { lab=Vbon}
N 1190 -20 1290 -20 { lab=GND}
N -610 340 -590 340 { lab=#net17}
N -490 360 -430 360 { lab=Vbn}
N 50 90 60 90 { lab=s2}
N 60 90 60 180 { lab=s2}
N 40 -200 110 -200 { lab=Vb2}
N -10 170 180 170 { lab=Vbn}
N 10 -90 10 50 { lab=b2}
N -10 130 -10 170 { lab=Vbn}
N 40 -200 40 -130 { lab=Vb2}
N -10 -350 10 -350 { lab=Vdr2}
N -10 -350 -10 -320 { lab=Vdr2}
N -10 -320 40 -320 { lab=Vdr2}
N 40 -250 40 -200 { lab=Vb2}
N -20 -200 40 -200 { lab=Vb2}
N 240 90 250 90 { lab=s3}
N 250 90 250 180 { lab=s3}
N 230 -200 300 -200 { lab=Vb3}
N 140 -290 330 -290 { lab=Vgt}
N 140 -290 140 -230 { lab=Vgt}
N 180 170 370 170 { lab=Vbn}
N 200 -90 200 50 { lab=b3}
N 180 130 180 170 { lab=Vbn}
N 230 -200 230 -130 { lab=Vb3}
N 180 -350 200 -350 { lab=Vdr3}
N 180 -350 180 -320 { lab=Vdr3}
N 180 -320 230 -320 { lab=Vdr3}
N 230 -250 230 -200 { lab=Vb3}
N 170 -200 230 -200 { lab=Vb3}
N 430 90 440 90 { lab=s4}
N 440 90 440 180 { lab=s4}
N 420 -200 490 -200 { lab=Vb4}
N 330 -290 520 -290 { lab=Vgt}
N 330 -290 330 -230 { lab=Vgt}
N 370 170 560 170 { lab=Vbn}
N 390 -90 390 50 { lab=b4}
N 370 130 370 170 { lab=Vbn}
N 420 -200 420 -130 { lab=Vb4}
N 370 -350 390 -350 { lab=Vdr4}
N 370 -350 370 -320 { lab=Vdr4}
N 370 -320 420 -320 { lab=Vdr4}
N 420 -250 420 -200 { lab=Vb4}
N 360 -200 420 -200 { lab=Vb4}
N 620 90 630 90 { lab=s5}
N 630 90 630 180 { lab=s5}
N 610 -200 680 -200 { lab=Vb5}
N 520 -290 710 -290 { lab=Vgt}
N 520 -290 520 -230 { lab=Vgt}
N 560 170 750 170 { lab=Vbn}
N 580 -90 580 50 { lab=b5}
N 560 130 560 170 { lab=Vbn}
N 610 -200 610 -130 { lab=Vb5}
N 560 -350 580 -350 { lab=Vdr5}
N 560 -350 560 -320 { lab=Vdr5}
N 560 -320 610 -320 { lab=Vdr5}
N 610 -250 610 -200 { lab=Vb5}
N 550 -200 610 -200 { lab=Vb5}
N 710 -290 710 -230 { lab=Vgt}
N -90 -290 -40 -290 { lab=Vgt}
N -40 -290 10 -290 { lab=Vgt}
N 10 -290 140 -290 { lab=Vgt}
N -90 -290 -90 -230 { lab=Vgt}
N -60 -200 -20 -200 { lab=Vb2}
N -120 170 -10 170 { lab=Vbn}
N 770 -90 770 50 { lab=b6}
N 750 130 750 170 { lab=Vbn}
N 810 90 820 90 { lab=s6}
N 820 90 820 180 { lab=s6}
N -430 170 -320 170 { lab=Vbn}
N 770 -360 770 -330 { lab=Vdr6}
N 1290 -20 1520 -20 { lab=GND}
N 1050 20 1050 80 { lab=Vdr6}
N 1050 -40 1050 20 { lab=Vdr6}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} -410 90 3 0 {name=X2}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} -200 90 3 0 {name=X3}
C {madvlsi/gnd.sym} -390 130 0 0 {name=l1 lab=GND}
C {madvlsi/gnd.sym} -180 130 0 0 {name=l2 lab=GND}
C {madvlsi/vsource.sym} -570 180 0 0 {name=Vdd
value=1.8}
C {madvlsi/vdd.sym} -570 150 0 0 {name=l9 lab=VDD}
C {madvlsi/gnd.sym} -570 210 0 0 {name=l10 lab=GND}
C {madvlsi/vsource.sym} -360 210 0 0 {name=Vb0
value="pwl 1n 0 2u 1.8 32u 1.8 33u 0 100u 0 "}
C {madvlsi/gnd.sym} -360 240 0 0 {name=l11 lab=GND}
C {madvlsi/vsource.sym} -150 210 0 0 {name=Vb1
value="pwl 32u 0 33u 1.8 63u 1.8 64u 0 100u 0"}
C {madvlsi/gnd.sym} -150 240 0 0 {name=l12 lab=GND}
C {madvlsi/vsource.sym} 60 210 0 0 {name=Vb2
value="pwl 63u 0 64u 1.8 94u 1.8 95u 0 100u 0"}
C {madvlsi/nmos3.sym} -380 -290 0 0 {name=M9
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -280 -200 1 0 {name=M10
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -190 -290 0 0 {name=M11
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -90 -200 1 0 {name=M12
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 800 -290 0 0 {name=M13
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -380 -90 0 0 {name=M18
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -190 -90 0 0 {name=M19
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 800 -90 0 0 {name=M20
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} -380 -60 0 0 {name=l18 lab=GND}
C {madvlsi/gnd.sym} -190 -60 0 0 {name=l19 lab=GND}
C {madvlsi/gnd.sym} 800 -60 0 0 {name=l20 lab=GND}
C {madvlsi/vdd.sym} -190 -380 0 0 {name=l6 lab=VDD}
C {madvlsi/vdd.sym} -380 -380 0 0 {name=l7 lab=VDD}
C {madvlsi/tt_models.sym} -600 -40 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {madvlsi/ammeter1.sym} 800 -330 0 0 {name=Vmeas}
C {devices/lab_pin.sym} -410 50 2 0 {name=l14 sig_type=std_logic lab=b0}
C {devices/lab_pin.sym} -230 10 2 0 {name=l15 sig_type=std_logic lab=b1}
C {devices/lab_pin.sym} -430 170 0 0 {name=l17 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} -360 90 1 0 {name=l21 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} -150 90 1 0 {name=l22 sig_type=std_logic lab=s1}
C {madvlsi/ammeter1.sym} -380 -130 0 0 {name=VIb0}
C {madvlsi/ammeter1.sym} -190 -130 0 0 {name=VIb1}
C {madvlsi/ammeter1.sym} 800 -130 0 0 {name=VIb2}
C {madvlsi/nmos3.sym} -340 450 0 0 {name=M1
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/ammeter1.sym} -340 410 0 0 {name=VIb3}
C {madvlsi/gnd.sym} -340 480 0 0 {name=l25 lab=GND}
C {madvlsi/vdd.sym} -340 290 0 0 {name=l26 lab=VDD}
C {madvlsi/pmos3.sym} 950 460 0 0 {name=M3
L=3
W=10
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 950 560 0 0 {name=M4
L=1
W=3
body=GND
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 950 650 0 0 {name=M5
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 950 680 0 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} 900 460 0 0 {name=l28 sig_type=std_logic lab=Vbp}
C {madvlsi/ammeter1.sym} 950 600 0 0 {name=Vim}
C {madvlsi/nmos3.sym} 1050 560 0 0 {name=M6
L=1
W=3
body=GND
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1050 460 0 0 {name=M7
L=1
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 950 430 0 0 {name=l29 lab=VDD}
C {madvlsi/vdd.sym} 1050 430 0 0 {name=l30 lab=VDD}
C {devices/lab_pin.sym} -490 320 1 0 {name=l4 sig_type=std_logic lab=Vbp}
C {devices/lab_pin.sym} 1110 560 1 0 {name=l33 sig_type=std_logic lab=Vg}
C {devices/lab_pin.sym} 770 -330 0 0 {name=l39 sig_type=std_logic lab=Vdr6}
C {devices/lab_pin.sym} -380 -180 2 0 {name=l57 sig_type=std_logic lab=Vb0}
C {devices/lab_pin.sym} -190 -180 2 0 {name=l58 sig_type=std_logic lab=Vb1}
C {devices/lab_pin.sym} 800 -180 2 0 {name=l59 sig_type=std_logic lab=Vb6}
C {devices/lab_pin.sym} -330 -320 2 0 {name=l37 sig_type=std_logic lab=Vdr1}
C {devices/lab_pin.sym} -240 -350 1 0 {name=l38 sig_type=std_logic lab=Vdr2}
C {madvlsi/ammeter1.sym} -380 -260 0 0 {name=VIb4}
C {madvlsi/ammeter1.sym} -190 -260 0 0 {name=VIb5}
C {madvlsi/ammeter1.sym} 800 -260 0 0 {name=VIb6}
C {madvlsi/ammeter1.sym} 1270 -740 0 0 {name=VIout}
C {madvlsi/gnd.sym} 1270 -630 0 0 {name=l40 lab=GND}
C {madvlsi/nmos3.sym} 1270 -350 1 0 {name=M24
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1360 -440 0 0 {name=M25
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1190 -440 0 0 {name=M27
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1130 -440 0 0 {name=l43 sig_type=std_logic lab=Vgo}
C {madvlsi/nmos3.sym} 1270 -660 0 0 {name=M16
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1270 -690 2 0 {name=l5 sig_type=std_logic lab=Vbout}
C {madvlsi/pmos3.sym} 800 -360 0 0 {name=M34
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 900 -390 0 0 {name=l35 lab=VDD}
C {madvlsi/nmos3.sym} 900 -290 0 0 {name=M35
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1010 -260 0 0 {name=l36 lab=GND}
C {madvlsi/nmos3.sym} 1010 -290 0 0 {name=M36
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 900 -260 0 0 {name=l45 lab=GND}
C {madvlsi/pmos3.sym} 900 -360 0 0 {name=M37
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 800 -390 0 0 {name=l46 lab=VDD}
C {madvlsi/pmos3.sym} 1080 80 0 0 {name=M38
L=1
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1080 180 0 0 {name=M39
L=1
W=3
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/ammeter1.sym} 1080 220 0 0 {name=Vim2}
C {madvlsi/nmos3.sym} 1180 180 0 0 {name=M41
L=1
W=3
body=GND
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1180 80 0 0 {name=M42
L=1
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1080 -70 0 0 {name=l50 lab=VDD}
C {madvlsi/vdd.sym} 1180 50 0 0 {name=l51 lab=VDD}
C {devices/lab_pin.sym} 870 -290 3 0 {name=l56 sig_type=std_logic lab=Vbon}
C {devices/lab_pin.sym} 1290 180 2 0 {name=l49 sig_type=std_logic lab=Vgo}
C {madvlsi/nmos3.sym} 1080 270 0 0 {name=M43
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1030 80 0 0 {name=l47 sig_type=std_logic lab=Vdr6}
C {devices/code_shown.sym} 1400 50 0 0 {name=SPICE only_toplevel=false value=".param Wt = 3
.param Lt = 1
.control
tran 0.01u 300u
run
plot tran1.i(Vmeas) tran1.i(Vbias) tran1.i(VIb3) tran1.i(VIout)
plot tran1.i(Vib0) tran1.i(Vib1) tran1.i(Vib2) 
*plot tran1.v(b0) tran1.v(b1) tran1.v(b2) tran1.v(vbn) 
*plot tran1.v(Vdr1) tran1.v(Vdr2) tran1.v(Vdr3)
plot tran1.v(Vbn) tran1.v(Vb0) tran1.v(Vb1) tran1.v(Vb2) tran1.v(Vbd)
plot tran1.i(VIout1) tran1.i(VIout) tran1.i(VIout2) tran1.i(Vmeas)
*plot tran1.i(Vib4) tran1.i(Vib5) tran1.i(Vib6)
*plot tran1.v(s0) tran1.v(s1) tran1.v(s2) 
*plot tran1.v(Vdr1) tran1.v(Vdr2) tran1.v(Vdr3) tran1.v(Vdr4) tran1.v(Vdr5)
reset
*dc Vdd 0 1.8 0.01
*plot dc.i(Vmeas) dc.i(Vbias) dc.i(VIb3) dc.i(VIout)
*plot dc.v(Vdr3) dc.v(Vbout)
.endc
.save all"}
C {devices/lab_pin.sym} -370 410 0 0 {name=l63 sig_type=std_logic lab=Vbd}
C {madvlsi/nmos3.sym} -340 380 0 0 {name=M2
L=1
W=3
body=GND
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -370 380 0 0 {name=l64 sig_type=std_logic lab=Vgt}
C {madvlsi/nmos3.sym} 1050 620 0 0 {name=M17
L=1
W=3
body=GND
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -880 -50 0 1 {name=M21
L=1.0
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -720 -50 0 0 {name=M58
L=1.0
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -880 80 0 0 {name=M59
L=1.0
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -720 80 0 1 {name=M60
L=1.0
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} -880 -80 0 0 {name=l65 lab=VDD}
C {madvlsi/vdd.sym} -720 -80 0 0 {name=l66 lab=VDD}
C {madvlsi/gnd.sym} -880 170 0 0 {name=l67 lab=GND}
C {madvlsi/gnd.sym} -720 170 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} -690 80 2 0 {name=l69 sig_type=std_logic lab=Vbd}
C {devices/lab_pin.sym} -910 80 0 0 {name=l70 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} -720 20 2 0 {name=l71 sig_type=std_logic lab=Vgt}
C {devices/lab_pin.sym} -500 -290 0 0 {name=l72 sig_type=std_logic lab=Vgt}
C {madvlsi/pmos3.sym} -380 -350 0 1 {name=M61
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -190 -350 0 0 {name=M62
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -340 320 0 0 {name=M63
L=1
W=3
body=VDD
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/ammeter1.sym} 1010 -330 0 0 {name=VIout1}
C {madvlsi/ammeter1.sym} 900 -330 0 0 {name=VIout2}
C {madvlsi/pmos3.sym} 1130 -960 2 0 {name=M72
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1270 -960 2 0 {name=M73
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1130 -850 2 0 {name=M74
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1270 -850 0 0 {name=M75
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1430 -850 2 0 {name=M76
L=1
W=3
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1130 -990 0 0 {name=l53 lab=VDD}
C {madvlsi/vdd.sym} 1270 -990 0 0 {name=l73 lab=VDD}
C {madvlsi/pmos3.sym} 1610 -520 0 1 {name=M77
L=1.0
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1770 -520 0 0 {name=M78
L=1.0
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1610 -390 0 0 {name=M79
L=1.0
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1770 -390 0 1 {name=M80
L=1.0
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1610 -550 0 0 {name=l74 lab=VDD}
C {madvlsi/vdd.sym} 1770 -550 0 0 {name=l75 lab=VDD}
C {devices/lab_pin.sym} 1800 -390 2 0 {name=l78 sig_type=std_logic lab=Vod}
C {devices/lab_pin.sym} 1770 -450 2 0 {name=l81 sig_type=std_logic lab=Vgot}
C {devices/lab_pin.sym} 1580 -390 0 0 {name=l80 sig_type=std_logic lab=Vbon}
C {devices/lab_pin.sym} 1010 -380 2 0 {name=l79 sig_type=std_logic lab=Vod}
C {madvlsi/nmos3.sym} 1690 -270 2 0 {name=M22
L=1.0
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1690 -240 0 0 {name=l41 lab=GND}
C {madvlsi/gnd.sym} 1080 300 0 0 {name=l76 lab=GND}
C {devices/lab_pin.sym} 1720 -270 2 0 {name=l31 sig_type=std_logic lab=Vbon}
C {devices/lab_pin.sym} 1160 -230 0 0 {name=l32 sig_type=std_logic lab=Vbon}
C {madvlsi/gnd.sym} 1290 -20 0 0 {name=l34 lab=GND}
C {madvlsi/resistor.sym} -620 370 0 0 {name=R1
value=100k
m=1}
C {madvlsi/gnd.sym} -620 400 0 0 {name=l8 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/ibias.sym} -540 340 0 0 {name=X1}
C {madvlsi/ammeter1.sym} -610 340 1 1 {name=Vbias}
C {devices/lab_pin.sym} 40 -320 2 0 {name=l27 sig_type=std_logic lab=Vdr2}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 10 90 3 0 {name=X5}
C {madvlsi/gnd.sym} 30 130 0 0 {name=l42 lab=GND}
C {madvlsi/vsource.sym} 250 210 0 0 {name=Vb3
value="pwl 93u 0 94u 1.8 124u 1.8 125u 0 200u 0"}
C {madvlsi/gnd.sym} 60 240 0 0 {name=l44 lab=GND}
C {madvlsi/nmos3.sym} 40 -290 0 0 {name=M8
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 140 -200 1 0 {name=M14
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 40 -90 0 0 {name=M40
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 40 -60 0 0 {name=l48 lab=GND}
C {madvlsi/vdd.sym} 40 -380 0 0 {name=l52 lab=VDD}
C {devices/lab_pin.sym} 10 50 2 0 {name=l54 sig_type=std_logic lab=b2}
C {devices/lab_pin.sym} 60 90 2 0 {name=l55 sig_type=std_logic lab=s2}
C {madvlsi/ammeter1.sym} 40 -130 0 0 {name=VIb7}
C {madvlsi/pmos3.sym} 40 -350 0 0 {name=M15
L=\{Lt\}
W=\{Wt\}
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 40 -180 2 0 {name=l60 sig_type=std_logic lab=Vb2}
C {devices/lab_pin.sym} 230 -320 2 0 {name=l61 sig_type=std_logic lab=Vdr3}
C {madvlsi/ammeter1.sym} 40 -260 0 0 {name=VIb8}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 200 90 3 0 {name=X6}
C {madvlsi/gnd.sym} 220 130 0 0 {name=l62 lab=GND}
C {madvlsi/vsource.sym} 440 210 0 0 {name=Vb4
value="pwl 123u 0 124u 1.8 154u 1.8 155u 0 200u 0"}
C {madvlsi/gnd.sym} 250 240 0 0 {name=l77 lab=GND}
C {madvlsi/nmos3.sym} 230 -290 0 0 {name=M23
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 330 -200 1 0 {name=M28
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 230 -90 0 0 {name=M44
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 230 -60 0 0 {name=l82 lab=GND}
C {madvlsi/vdd.sym} 230 -380 0 0 {name=l83 lab=VDD}
C {devices/lab_pin.sym} 200 50 2 0 {name=l84 sig_type=std_logic lab=b3}
C {devices/lab_pin.sym} 250 90 2 0 {name=l85 sig_type=std_logic lab=s3}
C {madvlsi/ammeter1.sym} 230 -130 0 0 {name=VIb9}
C {madvlsi/pmos3.sym} 230 -350 0 0 {name=M45
L=\{Lt\}
W=\{Wt\}
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 230 -180 2 0 {name=l86 sig_type=std_logic lab=Vb3}
C {devices/lab_pin.sym} 420 -320 2 0 {name=l87 sig_type=std_logic lab=Vdr4}
C {madvlsi/ammeter1.sym} 230 -260 0 0 {name=VIb10}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 390 90 3 0 {name=X7}
C {madvlsi/gnd.sym} 410 130 0 0 {name=l88 lab=GND}
C {madvlsi/vsource.sym} 630 210 0 0 {name=Vb5
value="pwl 183u 0 184u 1.8 214u 1.8 215u 0 220u 0"}
C {madvlsi/gnd.sym} 440 240 0 0 {name=l89 lab=GND}
C {madvlsi/nmos3.sym} 420 -290 0 0 {name=M46
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 520 -200 1 0 {name=M47
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 420 -90 0 0 {name=M48
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 420 -60 0 0 {name=l90 lab=GND}
C {madvlsi/vdd.sym} 420 -380 0 0 {name=l91 lab=VDD}
C {devices/lab_pin.sym} 390 50 2 0 {name=l92 sig_type=std_logic lab=b4}
C {devices/lab_pin.sym} 440 90 2 0 {name=l93 sig_type=std_logic lab=s4}
C {madvlsi/ammeter1.sym} 420 -130 0 0 {name=VIb11}
C {madvlsi/pmos3.sym} 420 -350 0 0 {name=M49
L=\{Lt\}
W=\{Wt\}
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 420 -180 2 0 {name=l94 sig_type=std_logic lab=Vb4}
C {devices/lab_pin.sym} 610 -320 2 0 {name=l95 sig_type=std_logic lab=Vdr5}
C {madvlsi/ammeter1.sym} 420 -260 0 0 {name=VIb12}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 580 90 3 0 {name=X8}
C {madvlsi/gnd.sym} 600 130 0 0 {name=l96 lab=GND}
C {madvlsi/gnd.sym} 630 240 0 0 {name=l97 lab=GND}
C {madvlsi/nmos3.sym} 610 -290 0 0 {name=M50
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 710 -200 1 0 {name=M51
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 610 -90 0 0 {name=M52
L=\{Lt\}
W=\{Wt\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 610 -60 0 0 {name=l98 lab=GND}
C {madvlsi/vdd.sym} 610 -380 0 0 {name=l99 lab=VDD}
C {devices/lab_pin.sym} 580 50 2 0 {name=l100 sig_type=std_logic lab=b5}
C {devices/lab_pin.sym} 630 90 2 0 {name=l101 sig_type=std_logic lab=s5}
C {madvlsi/ammeter1.sym} 610 -130 0 0 {name=VIb13}
C {madvlsi/pmos3.sym} 610 -350 0 0 {name=M53
L=\{Lt\}
W=\{Wt\}
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 610 -180 2 0 {name=l102 sig_type=std_logic lab=Vb5}
C {madvlsi/ammeter1.sym} 610 -260 0 0 {name=VIb14}
C {madvlsi/vsource.sym} 820 210 0 0 {name=Vb6
value="pwl 213u 0 214u 1.8 244u 1.8 245u 0 260u 0"}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 770 90 3 0 {name=X4}
C {madvlsi/gnd.sym} 790 130 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 770 50 2 0 {name=l13 sig_type=std_logic lab=b6}
C {devices/lab_pin.sym} 820 90 2 0 {name=l16 sig_type=std_logic lab=s6}
C {madvlsi/gnd.sym} 820 240 0 0 {name=l23 lab=GND}
C {madvlsi/nmos3.sym} 1190 -230 0 0 {name=M29
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1080 20 0 0 {name=M32
L=1
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1080 -40 0 0 {name=M33
L=1
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1190 -170 0 0 {name=M54
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1160 -170 0 0 {name=l106 sig_type=std_logic lab=Vbon}
C {madvlsi/nmos3.sym} 1190 -110 0 0 {name=M26
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1160 -110 0 0 {name=l103 sig_type=std_logic lab=Vbon}
C {madvlsi/nmos3.sym} 1190 -50 0 0 {name=M30
L=1
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1160 -50 0 0 {name=l104 sig_type=std_logic lab=Vbon}
