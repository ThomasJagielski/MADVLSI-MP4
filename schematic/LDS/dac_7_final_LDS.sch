v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 930 -1220 970 -1220 { lab=VDD}
N 1030 -1220 1070 -1220 { lab=#net1}
N 1130 -1220 1170 -1220 { lab=#net2}
N 1230 -1220 1270 -1220 { lab=VDD}
N 1330 -1220 1370 -1220 { lab=VDD}
N 1430 -1220 1470 -1220 { lab=#net3}
N 1530 -1220 1570 -1220 { lab=#net4}
N 1630 -1220 1670 -1220 { lab=VDD}
N 1730 -1220 1770 -1220 { lab=#net5}
N 1830 -1220 1870 -1220 { lab=VDD}
N 1930 -1220 1970 -1220 { lab=#net6}
N 2030 -1220 2070 -1220 { lab=VDD}
N 2130 -1220 2170 -1220 { lab=#net7}
N 2230 -1220 2270 -1220 { lab=out}
N 930 -990 970 -990 { lab=#net1}
N 1030 -990 1070 -990 { lab=#net2}
N 1130 -990 1170 -990 { lab=#net3}
N 1230 -990 1270 -990 { lab=#net2}
N 1330 -990 1370 -990 { lab=#net4}
N 1430 -990 1470 -990 { lab=#net3}
N 1530 -990 1570 -990 { lab=#net4}
N 1630 -990 1670 -990 { lab=#net5}
N 1730 -990 1770 -990 { lab=#net4}
N 1830 -990 1870 -990 { lab=#net6}
N 1930 -990 1970 -990 { lab=#net5}
N 2030 -990 2070 -990 { lab=#net6}
N 2130 -990 2170 -990 { lab=#net7}
N 1130 -780 1170 -780 { lab=#net1}
N 1230 -780 1270 -780 { lab=#net2}
N 1330 -780 1370 -780 { lab=GND}
N 1430 -780 1470 -780 { lab=#net3}
N 1530 -780 1570 -780 { lab=#net4}
N 1630 -780 1670 -780 { lab=GND}
N 1730 -780 1770 -780 { lab=#net5}
N 1830 -780 1870 -780 { lab=#net6}
N 1930 -780 1970 -780 { lab=GND}
N 730 -680 2590 -680 { lab=GND}
N 1050 -780 1050 -680 { lab=GND}
N 1100 -750 1100 -640 { lab=b0}
N 1300 -750 1300 -650 { lab=b1}
N 1400 -750 1400 -650 { lab=b2}
N 1600 -750 1600 -650 { lab=b3}
N 1700 -750 1700 -650 { lab=b4}
N 1900 -750 1900 -650 { lab=b5}
N 2000 -750 2000 -650 { lab=b6}
N 690 -1280 2550 -1280 { lab=Vg}
N 1200 -750 1200 -680 { lab=GND}
N 1500 -750 1500 -680 { lab=GND}
N 1800 -750 1800 -680 { lab=GND}
N 1950 -780 1950 -680 { lab=GND}
N 1350 -780 1350 -680 { lab=GND}
N 1650 -780 1650 -680 { lab=GND}
N 900 -1280 900 -1250 { lab=Vg}
N 1000 -1280 1000 -1250 { lab=Vg}
N 1200 -1280 1200 -1250 { lab=Vg}
N 1400 -1280 1400 -1250 { lab=Vg}
N 1600 -1280 1600 -1250 { lab=Vg}
N 1800 -1280 1800 -1250 { lab=Vg}
N 2000 -1280 2000 -1250 { lab=Vg}
N 2200 -1280 2200 -1250 { lab=Vg}
N 2300 -1280 2300 -1250 { lab=Vg}
N 850 -1220 850 -1160 { lab=#net1}
N 850 -1160 1050 -1160 { lab=#net1}
N 1050 -1220 1050 -1160 { lab=#net1}
N 2150 -1220 2150 -1160 { lab=#net7}
N 2150 -1160 2350 -1160 { lab=#net7}
N 2350 -1220 2350 -1160 { lab=#net7}
N 1100 -1250 1100 -1140 { lab=GND}
N 1300 -1250 1300 -1140 { lab=GND}
N 1500 -1250 1500 -1140 { lab=GND}
N 1700 -1250 1700 -1140 { lab=GND}
N 1900 -1250 1900 -1140 { lab=GND}
N 2100 -1250 2100 -1140 { lab=GND}
N 670 -1140 2100 -1140 { lab=GND}
N 670 -680 730 -680 { lab=GND}
N 850 -990 850 -920 { lab=#net2}
N 850 -920 1250 -920 { lab=#net2}
N 1250 -990 1250 -920 { lab=#net2}
N 1850 -990 1850 -920 { lab=#net6}
N 1850 -920 2250 -920 { lab=#net6}
N 2250 -990 2250 -920 { lab=#net6}
N 1350 -990 1350 -920 { lab=#net4}
N 1350 -920 1750 -920 { lab=#net4}
N 1750 -990 1750 -920 { lab=#net4}
N 1300 -1140 1300 -1020 { lab=GND}
N 1800 -1140 1800 -1020 { lab=GND}
N 900 -1030 900 -1020 { lab=Vg}
N 900 -1030 2200 -1030 { lab=Vg}
N 2200 -1030 2200 -1020 { lab=Vg}
N 2100 -1030 2100 -1020 { lab=Vg}
N 2000 -1030 2000 -1020 { lab=Vg}
N 1900 -1030 1900 -1020 { lab=Vg}
N 1700 -1030 1700 -1020 { lab=Vg}
N 1600 -1030 1600 -1020 { lab=Vg}
N 1500 -1030 1500 -1020 { lab=Vg}
N 1400 -1030 1400 -1020 { lab=Vg}
N 1200 -1030 1200 -1020 { lab=Vg}
N 1100 -1030 1100 -1020 { lab=Vg}
N 1000 -1030 1000 -1020 { lab=Vg}
N 950 -1380 950 -1220 { lab=VDD}
N 690 -1030 900 -1030 { lab=Vg}
N 950 -1160 950 -990 { lab=#net1}
N 950 -990 950 -850 { lab=#net1}
N 950 -850 1150 -850 { lab=#net1}
N 1150 -850 1150 -780 { lab=#net1}
N 1050 -990 1050 -920 { lab=#net2}
N 1050 -1110 1050 -990 { lab=#net2}
N 1050 -1110 1150 -1110 { lab=#net2}
N 1150 -1220 1150 -1110 { lab=#net2}
N 1250 -1380 1250 -1220 { lab=VDD}
N 1050 -920 1050 -870 { lab=#net2}
N 1050 -870 1250 -870 { lab=#net2}
N 1250 -870 1250 -780 { lab=#net2}
N 1350 -1380 1350 -1220 { lab=VDD}
N 2250 -1300 2250 -1220 { lab=out}
N 2250 -1300 2550 -1300 { lab=out}
N 1450 -1220 1450 -1090 { lab=#net3}
N 1150 -1090 1450 -1090 { lab=#net3}
N 1150 -1090 1150 -990 { lab=#net3}
N 1450 -1090 1450 -990 { lab=#net3}
N 1650 -1380 1650 -1220 { lab=VDD}
N 1450 -990 1450 -780 { lab=#net3}
N 2150 -990 2150 -860 { lab=#net7}
N 2150 -1160 2150 -990 { lab=#net7}
N 1950 -1220 1950 -1110 { lab=#net6}
N 1950 -1110 2050 -1110 { lab=#net6}
N 2050 -1110 2050 -990 { lab=#net6}
N 2050 -990 2050 -920 { lab=#net6}
N 1850 -920 1850 -780 { lab=#net6}
N 1750 -1070 1950 -1070 { lab=#net5}
N 1950 -1070 1950 -990 { lab=#net5}
N 1950 -990 1950 -880 { lab=#net5}
N 1750 -880 1950 -880 { lab=#net5}
N 1750 -880 1750 -780 { lab=#net5}
N 1550 -1220 1550 -990 { lab=#net4}
N 1550 -990 1550 -920 { lab=#net4}
N 1550 -920 1550 -780 { lab=#net4}
N 1650 -990 1650 -880 { lab=#net5}
N 1650 -880 1750 -880 { lab=#net5}
N 630 -1280 690 -1280 { lab=Vg}
N 630 -1280 630 -1030 { lab=Vg}
N 630 -1030 690 -1030 { lab=Vg}
N 650 -1140 670 -1140 { lab=GND}
N 650 -1140 650 -680 { lab=GND}
N 650 -680 670 -680 { lab=GND}
N 1750 -1220 1750 -1070 { lab=#net5}
N 700 -1250 800 -1250 { lab=GND}
N 730 -1220 770 -1220 { lab=GND}
N 670 -1250 670 -1220 { lab=GND}
N 670 -1250 700 -1250 { lab=GND}
N 750 -1250 750 -1220 { lab=GND}
N 830 -1220 870 -1220 { lab=#net1}
N 750 -1220 750 -1140 { lab=GND}
N 2330 -1220 2370 -1220 { lab=#net7}
N 2400 -1250 2500 -1250 { lab=GND}
N 2500 -1250 2530 -1250 { lab=GND}
N 2530 -1250 2530 -1220 { lab=GND}
N 2430 -1220 2470 -1220 { lab=GND}
N 2450 -1250 2450 -1220 { lab=GND}
N 2100 -1140 2450 -1140 { lab=GND}
N 2450 -1220 2450 -1140 { lab=GND}
N 830 -990 870 -990 { lab=#net2}
N 700 -1020 800 -1020 { lab=GND}
N 670 -1020 700 -1020 { lab=GND}
N 670 -1020 670 -990 { lab=GND}
N 730 -990 770 -990 { lab=GND}
N 750 -1020 750 -990 { lab=GND}
N 650 -990 670 -990 { lab=GND}
N 730 -780 770 -780 { lab=GND}
N 830 -780 870 -780 { lab=GND}
N 930 -780 970 -780 { lab=GND}
N 1030 -780 1070 -780 { lab=GND}
N 670 -750 1000 -750 { lab=GND}
N 670 -780 670 -750 { lab=GND}
N 750 -780 750 -750 { lab=GND}
N 850 -780 850 -750 { lab=GND}
N 950 -780 950 -750 { lab=GND}
N 850 -750 850 -680 { lab=GND}
N 2050 -860 2050 -780 { lab=#net7}
N 2050 -860 2150 -860 { lab=#net7}
N 2030 -780 2070 -780 { lab=#net7}
N 2100 -750 2530 -750 { lab=GND}
N 2530 -780 2530 -750 { lab=GND}
N 2430 -780 2470 -780 { lab=GND}
N 2330 -780 2370 -780 { lab=GND}
N 2230 -780 2270 -780 { lab=GND}
N 2130 -780 2170 -780 { lab=GND}
N 2150 -780 2150 -750 { lab=GND}
N 2250 -780 2250 -750 { lab=GND}
N 2350 -780 2350 -750 { lab=GND}
N 2450 -780 2450 -750 { lab=GND}
N 2300 -750 2300 -680 { lab=GND}
N 2230 -990 2270 -990 { lab=#net6}
N 2330 -990 2370 -990 { lab=GND}
N 2430 -990 2470 -990 { lab=GND}
N 2300 -1020 2530 -1020 { lab=GND}
N 2530 -1020 2530 -990 { lab=GND}
N 2450 -1020 2450 -990 { lab=GND}
N 2350 -1020 2350 -990 { lab=GND}
N 2450 -1140 2450 -1020 { lab=GND}
N 630 -1380 2590 -1380 { lab=VDD}
N 630 -1400 630 -1380 { lab=VDD}
N 650 -680 650 -640 { lab=GND}
N 2050 -1380 2050 -1220 { lab=VDD}
N 1850 -1380 1850 -1220 { lab=VDD}
N 3730 -1660 3730 -1640 { lab=#net1}
N 3730 -1640 3930 -1640 { lab=#net1}
N 3930 -1660 3930 -1640 { lab=#net1}
N 3830 -1660 3830 -1640 { lab=#net1}
N 3660 -1690 3700 -1690 { lab=Iin}
N 3760 -1690 3800 -1690 { lab=VDD}
N 3860 -1690 3900 -1690 { lab=#net2}
N 3580 -1690 3580 -1640 { lab=#net3}
N 3580 -1640 3580 -1570 { lab=#net3}
N 3680 -1690 3680 -1530 { lab=Iin}
N 3930 -1640 3980 -1640 { lab=#net1}
N 3980 -1690 4000 -1690 { lab=#net1}
N 3980 -1640 4230 -1640 { lab=#net1}
N 4230 -1660 4230 -1640 { lab=#net1}
N 4130 -1660 4130 -1640 { lab=#net1}
N 4030 -1660 4030 -1640 { lab=#net1}
N 4060 -1690 4100 -1690 { lab=#net2}
N 4160 -1690 4200 -1690 { lab=VDD}
N 4260 -1690 4300 -1690 { lab=Iin}
N 4380 -1690 4380 -1640 { lab=#net3}
N 4380 -1640 4380 -1570 { lab=#net3}
N 4280 -1690 4280 -1530 { lab=Iin}
N 3960 -1690 3980 -1690 { lab=#net1}
N 3530 -1880 3530 -1660 { lab=VDD}
N 4430 -1880 4430 -1660 { lab=VDD}
N 3360 -1690 3400 -1690 { lab=Vout}
N 3380 -1690 3380 -1610 { lab=Vout}
N 3460 -1690 3500 -1690 { lab=#net2}
N 3560 -1690 3600 -1690 { lab=#net3}
N 3430 -1660 3430 -1640 { lab=#net3}
N 3430 -1640 3600 -1640 { lab=#net3}
N 3600 -1640 3630 -1640 { lab=#net3}
N 3630 -1660 3630 -1640 { lab=#net3}
N 4360 -1690 4400 -1690 { lab=#net3}
N 4460 -1690 4500 -1690 { lab=#net2}
N 4330 -1660 4330 -1640 { lab=#net3}
N 4330 -1640 4380 -1640 { lab=#net3}
N 4380 -1640 4530 -1640 { lab=#net3}
N 4530 -1660 4530 -1640 { lab=#net3}
N 4560 -1690 4600 -1690 { lab=Vout}
N 4580 -1690 4580 -1610 { lab=Vout}
N 3480 -1790 3480 -1690 { lab=#net2}
N 3480 -1790 4480 -1790 { lab=#net2}
N 4480 -1790 4480 -1690 { lab=#net2}
N 4080 -1790 4080 -1690 { lab=#net2}
N 3880 -1790 3880 -1690 { lab=#net2}
N 3780 -1880 3780 -1690 { lab=VDD}
N 4180 -1880 4180 -1690 { lab=VDD}
N 3580 -1570 3580 -1500 { lab=#net3}
N 4380 -1570 4380 -1500 { lab=#net3}
N 3260 -1210 3300 -1210 { lab=VDD}
N 3360 -1210 3400 -1210 { lab=#net4}
N 3460 -1210 3500 -1210 { lab=#net5}
N 3560 -1210 3600 -1210 { lab=VDD}
N 3660 -1210 3700 -1210 { lab=VDD}
N 3760 -1210 3800 -1210 { lab=#net6}
N 3860 -1210 3900 -1210 { lab=#net7}
N 3960 -1210 4000 -1210 { lab=VDD}
N 4060 -1210 4100 -1210 { lab=#net8}
N 4160 -1210 4200 -1210 { lab=VDD}
N 4260 -1210 4300 -1210 { lab=#net3}
N 4360 -1210 4400 -1210 { lab=VDD}
N 4460 -1210 4500 -1210 { lab=#net9}
N 4560 -1210 4600 -1210 { lab=#net1}
N 3260 -980 3300 -980 { lab=#net4}
N 3360 -980 3400 -980 { lab=#net5}
N 3460 -980 3500 -980 { lab=#net6}
N 3560 -980 3600 -980 { lab=#net5}
N 3660 -980 3700 -980 { lab=#net7}
N 3760 -980 3800 -980 { lab=#net6}
N 3860 -980 3900 -980 { lab=#net7}
N 3960 -980 4000 -980 { lab=#net8}
N 4060 -980 4100 -980 { lab=#net7}
N 4160 -980 4200 -980 { lab=#net3}
N 4260 -980 4300 -980 { lab=#net8}
N 4360 -980 4400 -980 { lab=#net3}
N 4460 -980 4500 -980 { lab=#net9}
N 3460 -770 3500 -770 { lab=#net4}
N 3560 -770 3600 -770 { lab=#net5}
N 3660 -770 3700 -770 { lab=GND}
N 3760 -770 3800 -770 { lab=#net6}
N 3860 -770 3900 -770 { lab=#net7}
N 3960 -770 4000 -770 { lab=GND}
N 4060 -770 4100 -770 { lab=#net8}
N 4160 -770 4200 -770 { lab=#net3}
N 4260 -770 4300 -770 { lab=GND}
N 3380 -770 3380 -670 { lab=GND}
N 3430 -740 3430 -630 { lab=b0}
N 3530 -740 3530 -670 { lab=GND}
N 3830 -740 3830 -670 { lab=GND}
N 4130 -740 4130 -670 { lab=GND}
N 4280 -770 4280 -670 { lab=GND}
N 3680 -770 3680 -670 { lab=GND}
N 3980 -770 3980 -670 { lab=GND}
N 3230 -1270 3230 -1240 { lab=Vg}
N 3330 -1270 3330 -1240 { lab=Vg}
N 3530 -1270 3530 -1240 { lab=Vg}
N 3730 -1270 3730 -1240 { lab=Vg}
N 3930 -1270 3930 -1240 { lab=Vg}
N 4130 -1270 4130 -1240 { lab=Vg}
N 4330 -1270 4330 -1240 { lab=Vg}
N 4530 -1270 4530 -1240 { lab=Vg}
N 4630 -1270 4630 -1240 { lab=Vg}
N 3180 -1210 3180 -1150 { lab=#net4}
N 3180 -1150 3380 -1150 { lab=#net4}
N 3380 -1210 3380 -1150 { lab=#net4}
N 4480 -1210 4480 -1150 { lab=#net9}
N 4480 -1150 4680 -1150 { lab=#net9}
N 4680 -1210 4680 -1150 { lab=#net9}
N 3430 -1240 3430 -1130 { lab=GND}
N 3630 -1240 3630 -1130 { lab=GND}
N 3830 -1240 3830 -1130 { lab=GND}
N 4030 -1240 4030 -1130 { lab=GND}
N 4230 -1240 4230 -1130 { lab=GND}
N 4430 -1240 4430 -1130 { lab=GND}
N 3180 -980 3180 -910 { lab=#net5}
N 3180 -910 3580 -910 { lab=#net5}
N 3580 -980 3580 -910 { lab=#net5}
N 4180 -980 4180 -910 { lab=#net3}
N 4180 -910 4580 -910 { lab=#net3}
N 4580 -980 4580 -910 { lab=#net3}
N 3680 -980 3680 -910 { lab=#net7}
N 3680 -910 4080 -910 { lab=#net7}
N 4080 -980 4080 -910 { lab=#net7}
N 3630 -1130 3630 -1010 { lab=GND}
N 4130 -1130 4130 -1010 { lab=GND}
N 3230 -1020 3230 -1010 { lab=Vg}
N 3230 -1020 4530 -1020 { lab=Vg}
N 4530 -1020 4530 -1010 { lab=Vg}
N 4430 -1020 4430 -1010 { lab=Vg}
N 4330 -1020 4330 -1010 { lab=Vg}
N 4230 -1020 4230 -1010 { lab=Vg}
N 4030 -1020 4030 -1010 { lab=Vg}
N 3930 -1020 3930 -1010 { lab=Vg}
N 3830 -1020 3830 -1010 { lab=Vg}
N 3730 -1020 3730 -1010 { lab=Vg}
N 3530 -1020 3530 -1010 { lab=Vg}
N 3430 -1020 3430 -1010 { lab=Vg}
N 3330 -1020 3330 -1010 { lab=Vg}
N 3280 -1370 3280 -1210 { lab=VDD}
N 3020 -1020 3230 -1020 { lab=Vg}
N 3280 -1150 3280 -980 { lab=#net4}
N 3280 -980 3280 -840 { lab=#net4}
N 3280 -840 3480 -840 { lab=#net4}
N 3480 -840 3480 -770 { lab=#net4}
N 3380 -980 3380 -910 { lab=#net5}
N 3380 -1100 3380 -980 { lab=#net5}
N 3380 -1100 3480 -1100 { lab=#net5}
N 3480 -1210 3480 -1100 { lab=#net5}
N 3580 -1370 3580 -1210 { lab=VDD}
N 3380 -910 3380 -860 { lab=#net5}
N 3380 -860 3580 -860 { lab=#net5}
N 3580 -860 3580 -770 { lab=#net5}
N 3680 -1370 3680 -1210 { lab=VDD}
N 3780 -1210 3780 -1080 { lab=#net6}
N 3480 -1080 3780 -1080 { lab=#net6}
N 3480 -1080 3480 -980 { lab=#net6}
N 3780 -1080 3780 -980 { lab=#net6}
N 3980 -1370 3980 -1210 { lab=VDD}
N 3780 -980 3780 -770 { lab=#net6}
N 4480 -980 4480 -850 { lab=#net9}
N 4480 -1150 4480 -980 { lab=#net9}
N 4280 -1210 4280 -1100 { lab=#net3}
N 4280 -1100 4380 -1100 { lab=#net3}
N 4380 -1100 4380 -980 { lab=#net3}
N 4380 -980 4380 -910 { lab=#net3}
N 4180 -910 4180 -770 { lab=#net3}
N 4080 -1060 4280 -1060 { lab=#net8}
N 4280 -1060 4280 -980 { lab=#net8}
N 4280 -980 4280 -870 { lab=#net8}
N 4080 -870 4280 -870 { lab=#net8}
N 4080 -870 4080 -770 { lab=#net8}
N 3880 -1210 3880 -980 { lab=#net7}
N 3880 -980 3880 -910 { lab=#net7}
N 3880 -910 3880 -770 { lab=#net7}
N 3980 -980 3980 -870 { lab=#net8}
N 3980 -870 4080 -870 { lab=#net8}
N 2960 -1270 2960 -1020 { lab=Vg}
N 2960 -1020 3020 -1020 { lab=Vg}
N 2870 -1130 2870 -670 { lab=GND}
N 4080 -1210 4080 -1060 { lab=#net8}
N 3030 -1240 3130 -1240 { lab=GND}
N 3060 -1210 3100 -1210 { lab=GND}
N 3000 -1240 3000 -1210 { lab=GND}
N 3000 -1240 3030 -1240 { lab=GND}
N 3080 -1240 3080 -1210 { lab=GND}
N 3160 -1210 3200 -1210 { lab=#net4}
N 3080 -1210 3080 -1130 { lab=GND}
N 4660 -1210 4700 -1210 { lab=#net9}
N 4730 -1240 4830 -1240 { lab=GND}
N 4830 -1240 4860 -1240 { lab=GND}
N 4860 -1240 4860 -1210 { lab=GND}
N 4760 -1210 4800 -1210 { lab=GND}
N 4780 -1240 4780 -1210 { lab=GND}
N 4780 -1210 4780 -1130 { lab=GND}
N 3160 -980 3200 -980 { lab=#net5}
N 3030 -1010 3130 -1010 { lab=GND}
N 3060 -980 3100 -980 { lab=GND}
N 3080 -1010 3080 -980 { lab=GND}
N 3060 -770 3100 -770 { lab=GND}
N 3160 -770 3200 -770 { lab=GND}
N 3260 -770 3300 -770 { lab=GND}
N 3360 -770 3400 -770 { lab=GND}
N 3000 -740 3330 -740 { lab=GND}
N 3000 -770 3000 -740 { lab=GND}
N 3080 -770 3080 -740 { lab=GND}
N 3180 -770 3180 -740 { lab=GND}
N 3280 -770 3280 -740 { lab=GND}
N 3180 -740 3180 -670 { lab=GND}
N 4380 -850 4380 -770 { lab=#net9}
N 4380 -850 4480 -850 { lab=#net9}
N 4360 -770 4400 -770 { lab=#net9}
N 4430 -740 4860 -740 { lab=GND}
N 4860 -770 4860 -740 { lab=GND}
N 4760 -770 4800 -770 { lab=GND}
N 4660 -770 4700 -770 { lab=GND}
N 4560 -770 4600 -770 { lab=GND}
N 4460 -770 4500 -770 { lab=GND}
N 4480 -770 4480 -740 { lab=GND}
N 4580 -770 4580 -740 { lab=GND}
N 4680 -770 4680 -740 { lab=GND}
N 4780 -770 4780 -740 { lab=GND}
N 4630 -740 4630 -670 { lab=GND}
N 4560 -980 4600 -980 { lab=#net3}
N 4660 -980 4700 -980 { lab=GND}
N 4760 -980 4800 -980 { lab=GND}
N 4630 -1010 4860 -1010 { lab=GND}
N 4860 -1010 4860 -980 { lab=GND}
N 4780 -1010 4780 -980 { lab=GND}
N 4680 -1010 4680 -980 { lab=GND}
N 4780 -1130 4780 -1010 { lab=GND}
N 2870 -670 2870 -630 { lab=GND}
N 4380 -1370 4380 -1210 { lab=VDD}
N 4180 -1370 4180 -1210 { lab=VDD}
N 3580 -1500 4380 -1500 { lab=#net3}
N 3630 -740 3630 -670 { lab=GND}
N 3730 -740 3730 -670 { lab=GND}
N 3930 -740 3930 -670 { lab=GND}
N 4030 -740 4030 -670 { lab=GND}
N 4230 -740 4230 -670 { lab=GND}
N 4330 -740 4330 -670 { lab=GND}
N 2850 -1370 5030 -1370 { lab=VDD}
N 2870 -670 5050 -670 { lab=GND}
N 2870 -980 3000 -980 { lab=GND}
N 2980 -1010 2980 -980 { lab=GND}
N 2980 -1010 3030 -1010 { lab=GND}
N 2870 -1130 4780 -1130 { lab=GND}
N 3260 -1690 3300 -1690 { lab=VDD}
N 3330 -1660 3330 -1640 { lab=VDD}
N 3280 -1690 3280 -1640 { lab=VDD}
N 3280 -1880 3280 -1690 { lab=VDD}
N 4630 -1660 4630 -1640 { lab=VDD}
N 4630 -1640 4680 -1640 { lab=VDD}
N 4680 -1690 4680 -1640 { lab=VDD}
N 4660 -1690 4700 -1690 { lab=VDD}
N 4680 -1880 4680 -1690 { lab=VDD}
N 2850 -1880 5030 -1880 { lab=VDD}
N 2850 -1900 2850 -1370 { lab=VDD}
N 2800 -1610 5030 -1610 { lab=Vout}
N 2800 -1530 5030 -1530 { lab=Iin}
N 2980 -1690 3000 -1690 { lab=VDD}
N 2980 -1690 2980 -1640 { lab=VDD}
N 2980 -1640 3330 -1640 { lab=VDD}
N 3060 -1690 3100 -1690 { lab=VDD}
N 3160 -1690 3200 -1690 { lab=VDD}
N 3180 -1690 3180 -1640 { lab=VDD}
N 3080 -1690 3080 -1640 { lab=VDD}
N 3130 -1660 3130 -1640 { lab=VDD}
N 3030 -1660 3030 -1640 { lab=VDD}
N 3230 -1660 3230 -1640 { lab=VDD}
N 4730 -1660 4730 -1640 { lab=VDD}
N 4730 -1640 4880 -1640 { lab=VDD}
N 4880 -1690 4880 -1640 { lab=VDD}
N 4860 -1690 4880 -1690 { lab=VDD}
N 4830 -1660 4830 -1640 { lab=VDD}
N 4760 -1690 4800 -1690 { lab=VDD}
N 4780 -1690 4780 -1640 { lab=VDD}
N 4680 -1640 4730 -1640 { lab=VDD}
N 2800 -1270 5030 -1270 { lab=Vg}
N 4580 -1440 4580 -1210 { lab=#net1}
N 3980 -1440 4580 -1440 { lab=#net1}
N 3980 -1690 3980 -1440 { lab=#net1}
N 4280 -1500 4280 -1210 { lab=#net3}
N 1170 -1770 1210 -1770 { lab=#net1}
N 1170 -1650 1210 -1650 { lab=#net2}
N 1290 -1650 1310 -1650 { lab=GND}
N 1290 -1770 1310 -1770 { lab=VDD}
N 1370 -1770 1410 -1770 { lab=#net3}
N 1370 -1650 1410 -1650 { lab=#net4}
N 1470 -1650 1510 -1650 { lab=Vgt}
N 1470 -1770 1510 -1770 { lab=Vgt}
N 1370 -1540 1410 -1540 { lab=#net5}
N 1070 -1540 1110 -1540 { lab=#net6}
N 1170 -1540 1210 -1540 { lab=#net7}
N 1290 -1540 1310 -1540 { lab=GND}
N 1070 -1770 1110 -1770 { lab=#net6}
N 1070 -1650 1110 -1650 { lab=#net6}
N 1470 -1540 1510 -1540 { lab=Vgt}
N 1290 -1650 1290 -1540 { lab=GND}
N 1290 -1540 1290 -1490 { lab=GND}
N 1240 -1830 1240 -1800 { lab=#net6}
N 1240 -1620 1240 -1450 { lab=Vbn}
N 1140 -1830 1140 -1800 { lab=#net6}
N 1340 -1830 1340 -1800 { lab=#net6}
N 1440 -1830 1440 -1800 { lab=#net6}
N 1070 -1650 1070 -1540 { lab=#net6}
N 1510 -1650 1510 -1540 { lab=Vgt}
N 1170 -1880 1210 -1880 { lab=#net8}
N 1290 -1880 1310 -1880 { lab=VDD}
N 1370 -1880 1410 -1880 { lab=#net9}
N 1470 -1880 1510 -1880 { lab=Vgt}
N 1070 -1880 1110 -1880 { lab=#net6}
N 1070 -1830 1070 -1770 { lab=#net6}
N 1510 -1880 1510 -1770 { lab=Vgt}
N 1290 -1880 1290 -1770 { lab=VDD}
N 1290 -1910 1290 -1880 { lab=VDD}
N 1070 -1770 1070 -1650 { lab=#net6}
N 1510 -1710 1510 -1650 { lab=Vgt}
N 1140 -1830 1240 -1830 { lab=#net6}
N 1010 -1800 1040 -1800 { lab=VDD}
N 1010 -1800 1010 -1770 { lab=VDD}
N 1010 -1910 1040 -1910 { lab=VDD}
N 1010 -1910 1010 -1880 { lab=VDD}
N 1010 -1650 1010 -1620 { lab=GND}
N 1010 -1620 1040 -1620 { lab=GND}
N 1010 -1540 1010 -1510 { lab=GND}
N 1010 -1510 1040 -1510 { lab=GND}
N 1540 -1620 1570 -1620 { lab=GND}
N 1570 -1650 1570 -1620 { lab=GND}
N 1540 -1510 1570 -1510 { lab=GND}
N 1570 -1540 1570 -1510 { lab=GND}
N 1540 -1800 1570 -1800 { lab=VDD}
N 1570 -1800 1570 -1770 { lab=VDD}
N 1540 -1910 1570 -1910 { lab=VDD}
N 1570 -1910 1570 -1880 { lab=VDD}
N 1140 -1620 1140 -1450 { lab=Vbn}
N 1240 -1830 1340 -1830 { lab=#net6}
N 1340 -1830 1440 -1830 { lab=#net6}
N 1140 -1450 1240 -1450 { lab=Vbn}
N 1070 -1830 1140 -1830 { lab=#net6}
N 2030 -1710 2130 -1710 { lab=Vgt}
N 2230 -1620 2260 -1620 { lab=GND}
N 2260 -1650 2260 -1620 { lab=GND}
N 2230 -1510 2260 -1510 { lab=GND}
N 2260 -1540 2260 -1510 { lab=GND}
N 2230 -1850 2260 -1850 { lab=GND}
N 2260 -1880 2260 -1850 { lab=GND}
N 2230 -1740 2260 -1740 { lab=GND}
N 2260 -1770 2260 -1740 { lab=GND}
N 1700 -1650 1700 -1620 { lab=GND}
N 1700 -1620 1730 -1620 { lab=GND}
N 1700 -1540 1700 -1510 { lab=GND}
N 1700 -1510 1730 -1510 { lab=GND}
N 1700 -1880 1700 -1850 { lab=GND}
N 1700 -1850 1730 -1850 { lab=GND}
N 1700 -1770 1700 -1740 { lab=GND}
N 1700 -1740 1730 -1740 { lab=GND}
N 1270 -1650 1290 -1650 { lab=GND}
N 1270 -1540 1290 -1540 { lab=GND}
N 1270 -1880 1290 -1880 { lab=VDD}
N 1270 -1770 1290 -1770 { lab=VDD}
N 1140 -1850 1140 -1830 { lab=#net6}
N 1240 -1850 1240 -1830 { lab=#net6}
N 1340 -1850 1340 -1830 { lab=#net6}
N 1440 -1850 1440 -1830 { lab=#net6}
N 1070 -1880 1070 -1830 { lab=#net6}
N 1510 -1770 1510 -1710 { lab=Vgt}
N 1780 -1770 1800 -1770 { lab=VDD}
N 1780 -1650 1800 -1650 { lab=VDD}
N 1780 -1880 1800 -1880 { lab=VDD}
N 1780 -1540 1800 -1540 { lab=VDD}
N 1880 -1770 1900 -1770 { lab=#net10}
N 1880 -1880 1900 -1880 { lab=#net11}
N 1880 -1540 1900 -1540 { lab=#net12}
N 1980 -1770 2000 -1770 { lab=#net13}
N 1980 -1880 2000 -1880 { lab=#net13}
N 2180 -1770 2200 -1770 { lab=VDD}
N 2180 -1650 2200 -1650 { lab=VDD}
N 2180 -1880 2200 -1880 { lab=VDD}
N 2180 -1540 2200 -1540 { lab=VDD}
N 1780 -1910 1780 -1880 { lab=VDD}
N 1760 -1880 1780 -1880 { lab=VDD}
N 1780 -1880 1780 -1770 { lab=VDD}
N 1760 -1770 1780 -1770 { lab=VDD}
N 1780 -1770 1780 -1650 { lab=VDD}
N 1760 -1650 1780 -1650 { lab=VDD}
N 1780 -1650 1780 -1540 { lab=VDD}
N 1760 -1540 1780 -1540 { lab=VDD}
N 2080 -1770 2100 -1770 { lab=#net10}
N 2080 -1880 2100 -1880 { lab=#net11}
N 2080 -1540 2100 -1540 { lab=#net12}
N 2180 -1910 2180 -1880 { lab=VDD}
N 2180 -1880 2180 -1770 { lab=VDD}
N 2180 -1770 2180 -1650 { lab=VDD}
N 2180 -1650 2180 -1540 { lab=VDD}
N 2160 -1880 2180 -1880 { lab=VDD}
N 2160 -1770 2180 -1770 { lab=VDD}
N 2160 -1650 2180 -1650 { lab=VDD}
N 2160 -1540 2180 -1540 { lab=VDD}
N 1880 -1650 1900 -1650 { lab=#net14}
N 1980 -1650 2000 -1650 { lab=#net13}
N 2080 -1650 2100 -1650 { lab=#net14}
N 1830 -1710 1830 -1680 { lab=Vgt}
N 1510 -1710 1830 -1710 { lab=Vgt}
N 1830 -1850 1830 -1710 { lab=Vgt}
N 1930 -1710 1930 -1680 { lab=Vgt}
N 1830 -1710 1930 -1710 { lab=Vgt}
N 1930 -1850 1930 -1710 { lab=Vgt}
N 2030 -1710 2030 -1680 { lab=Vgt}
N 2030 -1850 2030 -1710 { lab=Vgt}
N 1930 -1710 2030 -1710 { lab=Vgt}
N 2130 -1710 2130 -1680 { lab=Vgt}
N 1980 -1880 1980 -1770 { lab=#net13}
N 1960 -1880 1980 -1880 { lab=#net13}
N 1960 -1770 1980 -1770 { lab=#net13}
N 1980 -1770 1980 -1650 { lab=#net13}
N 1960 -1650 1980 -1650 { lab=#net13}
N 1880 -1570 1880 -1540 { lab=#net12}
N 1860 -1540 1880 -1540 { lab=#net12}
N 1880 -1570 2080 -1570 { lab=#net12}
N 2080 -1570 2080 -1540 { lab=#net12}
N 2060 -1540 2080 -1540 { lab=#net12}
N 1880 -1650 1880 -1620 { lab=#net14}
N 1860 -1650 1880 -1650 { lab=#net14}
N 1880 -1620 2080 -1620 { lab=#net14}
N 2080 -1650 2080 -1620 { lab=#net14}
N 2060 -1650 2080 -1650 { lab=#net14}
N 2080 -1800 2080 -1770 { lab=#net10}
N 2060 -1770 2080 -1770 { lab=#net10}
N 1880 -1800 2080 -1800 { lab=#net10}
N 1880 -1800 1880 -1770 { lab=#net10}
N 1860 -1770 1880 -1770 { lab=#net10}
N 1880 -1910 1880 -1880 { lab=#net11}
N 1860 -1880 1880 -1880 { lab=#net11}
N 1880 -1910 2080 -1910 { lab=#net11}
N 2080 -1910 2080 -1880 { lab=#net11}
N 2060 -1880 2080 -1880 { lab=#net11}
N 2130 -1510 2130 -1450 { lab=Vbn}
N 2030 -1510 2030 -1450 { lab=Vbn}
N 1930 -1510 1930 -1450 { lab=Vbn}
N 1830 -1510 1830 -1450 { lab=Vbn}
N 2030 -1450 2130 -1450 { lab=Vbn}
N 1930 -1450 2030 -1450 { lab=Vbn}
N 1830 -1450 1930 -1450 { lab=Vbn}
N 1240 -1450 1830 -1450 { lab=Vbn}
N 1980 -1590 1980 -1540 { lab=#net13}
N 2130 -1850 2130 -1710 { lab=Vgt}
N 1340 -1590 1340 -1570 { lab=#net13}
N 1440 -1590 1440 -1570 { lab=#net13}
N 1340 -1590 1440 -1590 { lab=#net13}
N 1340 -1620 1340 -1590 { lab=#net13}
N 1440 -1620 1440 -1590 { lab=#net13}
N 1440 -1590 1980 -1590 { lab=#net13}
N 1980 -1650 1980 -1590 { lab=#net13}
N 1960 -1540 1980 -1540 { lab=#net13}
N 1980 -1540 2000 -1540 { lab=#net13}
N 2130 -1710 2350 -1710 { lab=Vgt}
N 1680 30 1680 50 { lab=#net1}
N 1560 30 1560 50 { lab=#net1}
N 1440 30 1440 50 { lab=#net1}
N 1320 30 1320 50 { lab=#net1}
N 1350 80 1410 80 { lab=#net1}
N 1380 30 1380 80 { lab=#net1}
N 1470 80 1530 80 { lab=#net1}
N 1500 30 1500 80 { lab=#net1}
N 1590 80 1650 80 { lab=#net1}
N 1620 30 1620 80 { lab=#net1}
N 1470 -140 1530 -140 { lab=#net2}
N 1830 -140 1890 -140 { lab=#net3}
N 2070 -140 2130 -140 { lab=#net4}
N 2430 -140 2490 -140 { lab=#net5}
N 1800 -110 1800 -90 { lab=#net6}
N 2160 -110 2160 -90 { lab=#net6}
N 1920 -110 1920 -90 { lab=#net6}
N 2040 -110 2040 -90 { lab=#net6}
N 1440 -110 1440 -60 { lab=Vbp}
N 2520 -110 2520 -60 { lab=Vbp}
N 2400 -110 2400 -60 { lab=Vbp}
N 1560 -110 1560 -60 { lab=Vbp}
N 1380 -260 1380 -140 { lab=#net7}
N 2580 -260 2580 -140 { lab=#net7}
N 1950 -140 2010 -140 { lab=#net7}
N 1980 -260 1980 -140 { lab=#net7}
N 1920 30 1920 50 { lab=#net1}
N 2040 30 2040 50 { lab=#net1}
N 1950 80 2010 80 { lab=#net8}
N 2310 80 2370 80 { lab=#net9}
N 2550 80 2610 80 { lab=#net10}
N 1740 80 1740 160 { lab=Vr}
N 2280 30 2280 50 { lab=Vbn}
N 2640 30 2640 50 { lab=Vbn}
N 2520 30 2520 50 { lab=Vbn}
N 2400 30 2400 50 { lab=Vbn}
N 2430 80 2490 80 { lab=GND}
N 2460 80 2460 200 { lab=GND}
N 1860 80 1860 200 { lab=GND}
N 2700 30 2700 80 { lab=Vbn}
N 2220 -60 2220 80 { lab=Vbp}
N 1590 -140 1650 -140 { lab=#net1}
N 1710 -140 1770 -140 { lab=#net6}
N 1680 -260 1680 -110 { lab=#net7}
N 1620 -140 1620 30 { lab=#net1}
N 2310 -140 2370 -140 { lab=Vbn}
N 2340 -140 2340 30 { lab=Vbn}
N 2190 -140 2250 -140 { lab=Vbp}
N 2220 -140 2220 -60 { lab=Vbp}
N 2280 -260 2280 -110 { lab=#net7}
N 1830 80 1890 80 { lab=GND}
N 1710 80 1770 80 { lab=Vr}
N 1800 50 1800 200 { lab=GND}
N 2070 80 2130 80 { lab=#net6}
N 2100 -90 2100 80 { lab=#net6}
N 2190 80 2250 80 { lab=Vbp}
N 2160 50 2160 200 { lab=GND}
N 2760 30 2760 50 { lab=Vbn}
N 2880 30 2880 50 { lab=Vbn}
N 3000 30 3000 50 { lab=Vbn}
N 3120 30 3120 50 { lab=Vbn}
N 2670 80 2730 80 { lab=Vbn}
N 2280 30 3120 30 { lab=Vbn}
N 2790 80 2850 80 { lab=#net11}
N 2910 80 2970 80 { lab=GND}
N 3030 80 3090 80 { lab=#net12}
N 2940 80 2940 200 { lab=GND}
N 2550 -140 2610 -140 { lab=#net7}
N 2640 -110 2640 -100 { lab=#net7}
N 2640 -100 2760 -100 { lab=#net7}
N 2760 -110 2760 -100 { lab=#net7}
N 2670 -140 2730 -140 { lab=#net7}
N 2700 -260 2700 -140 { lab=#net7}
N 2700 -140 2700 -100 { lab=#net7}
N 2790 -140 2850 -140 { lab=#net7}
N 2820 -260 2820 -140 { lab=#net7}
N 2880 -110 2880 -60 { lab=Vbp}
N 3000 -110 3000 -60 { lab=Vbp}
N 3960 -110 3960 -60 { lab=Vbp}
N 3840 -110 3840 -60 { lab=Vbp}
N 3240 -110 3240 -90 { lab=#net6}
N 3360 -110 3360 -90 { lab=#net6}
N 3480 -110 3480 -90 { lab=#net6}
N 3600 -110 3600 -90 { lab=#net6}
N 3120 -260 3120 -110 { lab=#net7}
N 3720 -260 3720 -110 { lab=#net7}
N 1740 -140 1740 -90 { lab=#net6}
N 1740 -90 2160 -90 { lab=#net6}
N 2910 -140 2970 -140 { lab=#net13}
N 3030 -140 3090 -140 { lab=Vbn}
N 3150 -140 3210 -140 { lab=Vbp}
N 3270 -140 3330 -140 { lab=#net14}
N 3390 -140 3450 -140 { lab=#net15}
N 3510 -140 3570 -140 { lab=#net16}
N 3630 -140 3690 -140 { lab=#net6}
N 3750 -140 3810 -140 { lab=#net1}
N 3870 -140 3930 -140 { lab=#net17}
N 3150 80 3210 80 { lab=Vbp}
N 3270 80 3330 80 { lab=#net6}
N 3390 80 3450 80 { lab=#net18}
N 3510 80 3570 80 { lab=GND}
N 3630 80 3690 80 { lab=Vr}
N 3750 80 3810 80 { lab=#net1}
N 3870 80 3930 80 { lab=#net1}
N 3990 80 4050 80 { lab=#net1}
N 4080 30 4080 50 { lab=#net1}
N 4140 30 4140 80 { lab=#net1}
N 3720 30 3720 50 { lab=#net1}
N 3840 30 3840 50 { lab=#net1}
N 3960 30 3960 50 { lab=#net1}
N 3780 30 3780 80 { lab=#net1}
N 3900 30 3900 80 { lab=#net1}
N 4020 30 4020 80 { lab=#net1}
N 1440 -60 3960 -60 { lab=Vbp}
N 3660 -140 3660 -90 { lab=#net6}
N 3240 -90 3660 -90 { lab=#net6}
N 3060 -140 3060 30 { lab=Vbn}
N 3180 -140 3180 -60 { lab=Vbp}
N 3180 -60 3180 80 { lab=Vbp}
N 3240 50 3240 200 { lab=GND}
N 3600 50 3600 200 { lab=GND}
N 3540 80 3540 200 { lab=GND}
N 3660 80 3660 160 { lab=Vr}
N 3300 -90 3300 80 { lab=#net6}
N 3360 30 3360 50 { lab=#net1}
N 3480 30 3480 50 { lab=#net1}
N 3360 30 4140 30 { lab=#net1}
N 4020 -260 4020 -140 { lab=#net7}
N 3780 -140 3780 30 { lab=#net1}
N 2100 -30 3300 -30 { lab=#net6}
N 1620 0 3780 0 { lab=#net1}
N 2700 80 2700 260 { lab=Vbn}
N 1200 30 1200 50 { lab=#net19}
N 1140 30 1140 80 { lab=#net19}
N 1140 80 1170 80 { lab=#net19}
N 1140 30 1200 30 { lab=#net19}
N 1350 -140 1410 -140 { lab=#net7}
N 1320 -110 1320 -90 { lab=#net20}
N 1230 80 1290 80 { lab=#net1}
N 1260 30 1260 80 { lab=#net1}
N 1260 30 2040 30 { lab=#net1}
N 4110 80 4170 80 { lab=#net1}
N 4200 30 4200 50 { lab=GND}
N 4200 30 4260 30 { lab=GND}
N 4260 30 4260 80 { lab=GND}
N 4230 80 4260 80 { lab=GND}
N 4260 80 4260 200 { lab=GND}
N 3990 -140 4050 -140 { lab=#net7}
N 4080 -110 4080 -90 { lab=#net21}
N 4080 -90 4200 -90 { lab=#net21}
N 4200 -110 4200 -90 { lab=#net21}
N 4110 -140 4170 -140 { lab=#net21}
N 4140 -140 4140 -90 { lab=#net21}
N 4230 -140 4260 -140 { lab=#net7}
N 4260 -260 4260 -140 { lab=#net7}
N 1230 -140 1290 -140 { lab=#net20}
N 1200 -110 1200 -90 { lab=#net20}
N 1200 -90 1320 -90 { lab=#net20}
N 1260 -140 1260 -90 { lab=#net20}
N 1140 -90 1200 -90 { lab=#net20}
N 1140 -140 1140 -90 { lab=#net20}
N 1140 -140 1170 -140 { lab=#net20}
N 1090 160 3660 160 { lab=Vr}
N 1090 200 4410 200 { lab=GND}
N 2700 260 4410 260 { lab=Vbn}
N 3960 -60 4410 -60 {}
N 1090 -260 4410 -260 { lab=GND}
N 1190 -520 1200 -520 { lab=s1}
N 1200 -520 1200 -430 { lab=s1}
N 980 -520 990 -520 { lab=s0}
N 990 -520 990 -430 { lab=s0}
N 1030 -440 1130 -440 { lab=Vbn}
N 1130 -440 1230 -440 { lab=Vbn}
N 920 -480 920 -440 { lab=Vbn}
N 1130 -480 1130 -440 { lab=Vbn}
N 1400 -520 1410 -520 { lab=s2}
N 1410 -520 1410 -430 { lab=s2}
N 1340 -440 1530 -440 { lab=Vbn}
N 1340 -480 1340 -440 { lab=Vbn}
N 1590 -520 1600 -520 { lab=s3}
N 1600 -520 1600 -430 { lab=s3}
N 1530 -440 1720 -440 { lab=Vbn}
N 1530 -480 1530 -440 { lab=Vbn}
N 1780 -520 1790 -520 { lab=s4}
N 1790 -520 1790 -430 { lab=s4}
N 1720 -440 1910 -440 { lab=Vbn}
N 1720 -480 1720 -440 { lab=Vbn}
N 1970 -520 1980 -520 { lab=s5}
N 1980 -520 1980 -430 { lab=s5}
N 1910 -440 2100 -440 { lab=Vbn}
N 1910 -480 1910 -440 { lab=Vbn}
N 1230 -440 1340 -440 { lab=Vbn}
N 2100 -480 2100 -440 { lab=Vbn}
N 2160 -520 2170 -520 { lab=s6}
N 2170 -520 2170 -430 { lab=s6}
N 920 -440 1030 -440 { lab=Vbn}
N 2000 -650 2120 -650 {}
N 2120 -650 2120 -560 {}
N 1900 -650 1930 -650 {}
N 1930 -650 1930 -560 {}
N 1700 -650 1740 -650 {}
N 1740 -650 1740 -560 {}
N 1550 -650 1550 -560 {}
N 1550 -650 1600 -650 {}
N 1360 -650 1360 -560 {}
N 1360 -650 1400 -650 {}
N 1150 -650 1150 -560 {}
N 1150 -650 1300 -650 {}
N 940 -640 940 -560 {}
N 940 -640 1100 -640 {}
N 2550 -1300 2720 -1300 {}
N 2720 -1530 2720 -1300 {}
N 2720 -1530 2800 -1530 {}
N 2550 -1280 2800 -1280 {}
N 2800 -1280 2800 -1270 {}
N 1000 160 1090 160 {}
C {madvlsi/nmos3.sym} 900 -1220 1 0 {name=M3a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1000 -1220 1 0 {name=M3b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1100 -1220 1 0 {name=M4
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1200 -1220 1 0 {name=M5
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1300 -1220 1 0 {name=M6
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1400 -1220 1 0 {name=M7
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1500 -1220 1 0 {name=M8
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1600 -1220 1 0 {name=M9
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1700 -1220 1 0 {name=M10
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1800 -1220 1 0 {name=M11
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1900 -1220 1 0 {name=M12
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2000 -1220 1 0 {name=M13
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2100 -1220 1 0 {name=M14
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2200 -1220 1 0 {name=M15a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2300 -1220 1 0 {name=M15b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 900 -990 1 0 {name=M20a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1000 -990 1 0 {name=M20b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1100 -990 1 0 {name=M21a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1200 -990 1 0 {name=M21b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1300 -990 1 0 {name=M22
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1400 -990 1 0 {name=M23a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1500 -990 1 0 {name=M23b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1600 -990 1 0 {name=M24a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1700 -990 1 0 {name=M24b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1800 -990 1 0 {name=M25
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1900 -990 1 0 {name=M26a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2000 -990 1 0 {name=M26b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2100 -990 1 0 {name=M27a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2200 -990 1 0 {name=M27b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1100 -780 3 0 {name=M35
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1200 -780 3 0 {name=M36
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1300 -780 3 0 {name=M37
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1400 -780 3 0 {name=M38
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1500 -780 3 0 {name=M39
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1600 -780 3 0 {name=M40
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1700 -780 3 0 {name=M41
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1800 -780 3 0 {name=M42
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1900 -780 3 0 {name=M43
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2000 -780 3 0 {name=M44
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1100 -640 3 0 {name=l5 sig_type=std_logic lab=b0}
C {devices/lab_pin.sym} 1400 -650 3 0 {name=l6 sig_type=std_logic lab=b2}
C {devices/lab_pin.sym} 1300 -650 3 0 {name=l7 sig_type=std_logic lab=b1}
C {devices/lab_pin.sym} 1900 -650 3 0 {name=l8 sig_type=std_logic lab=b5}
C {devices/lab_pin.sym} 1600 -650 3 0 {name=l9 sig_type=std_logic lab=b3}
C {devices/lab_pin.sym} 1700 -650 3 0 {name=l10 sig_type=std_logic lab=b4}
C {devices/lab_pin.sym} 2000 -650 3 0 {name=l11 sig_type=std_logic lab=b6}
C {madvlsi/nmos3.sym} 2400 -1220 1 0 {name=M16
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2500 -1220 1 0 {name=M17
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 800 -1220 1 0 {name=M2
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 700 -1220 1 0 {name=M1
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 800 -990 1 0 {name=M19
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 700 -990 1 0 {name=M18
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2300 -990 1 0 {name=M28
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2400 -990 1 0 {name=M29
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2500 -990 1 0 {name=M30
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2100 -780 3 0 {name=M45
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2200 -780 3 0 {name=M46
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2300 -780 3 0 {name=M47
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2400 -780 3 0 {name=M48
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2500 -780 3 0 {name=M49
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1000 -780 3 0 {name=M34
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 900 -780 3 0 {name=M33
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 800 -780 3 0 {name=M32
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 700 -780 3 0 {name=M31
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2590 -680 3 0 {name=l14 lab=GND}
C {madvlsi/vdd.sym} 630 -1400 0 0 {name=l13 lab=VDD}
C {madvlsi/gnd.sym} 650 -640 0 0 {name=l16 lab=GND}
C {madvlsi/pmos3.sym} 3530 -1690 3 0 {name=M3
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3630 -1690 3 0 {name=M2a
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3730 -1690 3 0 {name=M15
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3830 -1690 3 0 {name=M4a
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3930 -1690 3 0 {name=M5a
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4030 -1690 3 0 {name=M5b
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4130 -1690 3 0 {name=M4b
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4230 -1690 3 0 {name=M20
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4330 -1690 3 0 {name=M2b
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4430 -1690 3 0 {name=M21
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3430 -1690 3 0 {name=M1a
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4530 -1690 3 0 {name=M1b
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3330 -1690 3 0 {name=M23
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4630 -1690 3 0 {name=M24
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 2850 -1900 0 0 {name=l1 lab=VDD}
C {madvlsi/nmos3.sym} 3230 -1210 1 0 {name=M26
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3330 -1210 1 0 {name=M27
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3430 -1210 1 0 {name=M50
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3530 -1210 1 0 {name=M51
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3630 -1210 1 0 {name=M52
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3730 -1210 1 0 {name=M53
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3830 -1210 1 0 {name=M54
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3930 -1210 1 0 {name=M55
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4030 -1210 1 0 {name=M56
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4130 -1210 1 0 {name=M57
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4230 -1210 1 0 {name=M58
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4330 -1210 1 0 {name=M59
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4430 -1210 1 0 {name=M60
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4530 -1210 1 0 {name=M61
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4630 -1210 1 0 {name=M62
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3230 -980 1 0 {name=M63
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3330 -980 1 0 {name=M64
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3430 -980 1 0 {name=M65
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3530 -980 1 0 {name=M66
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3630 -980 1 0 {name=M67
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3730 -980 1 0 {name=M68
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3830 -980 1 0 {name=M69
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3930 -980 1 0 {name=M70
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4030 -980 1 0 {name=M71
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4130 -980 1 0 {name=M72
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4230 -980 1 0 {name=M73
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4330 -980 1 0 {name=M74
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4430 -980 1 0 {name=M75
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4530 -980 1 0 {name=M76
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3430 -770 3 0 {name=M77
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3530 -770 3 0 {name=M78
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3630 -770 3 0 {name=M79
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3730 -770 3 0 {name=M80
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3830 -770 3 0 {name=M81
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3930 -770 3 0 {name=M82
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4030 -770 3 0 {name=M83
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4130 -770 3 0 {name=M84
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4230 -770 3 0 {name=M85
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4330 -770 3 0 {name=M86
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4730 -1210 1 0 {name=M87
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4830 -1210 1 0 {name=M88
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3130 -1210 1 0 {name=M89
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3030 -1210 1 0 {name=M90
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3130 -980 1 0 {name=M91
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3030 -980 1 0 {name=M92
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4630 -980 1 0 {name=M93
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4730 -980 1 0 {name=M94
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4830 -980 1 0 {name=M95
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4430 -770 3 0 {name=M96
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4530 -770 3 0 {name=M97
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4630 -770 3 0 {name=M98
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4730 -770 3 0 {name=M99
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4830 -770 3 0 {name=M100
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3330 -770 3 0 {name=M101
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3230 -770 3 0 {name=M102
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3130 -770 3 0 {name=M103
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3030 -770 3 0 {name=M104
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2870 -630 0 0 {name=l4 lab=GND}
C {madvlsi/pmos3.sym} 4730 -1690 3 0 {name=M105
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4830 -1690 3 0 {name=M106
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3230 -1690 3 0 {name=M107
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3130 -1690 3 0 {name=M108
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3030 -1690 3 0 {name=M109
L=1
W=1.5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1140 -1770 1 0 {name=M110
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1240 -1770 1 0 {name=M111
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1340 -1770 1 0 {name=M112
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1440 -1770 1 0 {name=M113
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1140 -1880 3 0 {name=M114
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1240 -1880 3 0 {name=M115
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1340 -1880 3 0 {name=M116
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1440 -1880 3 0 {name=M117
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1290 -1490 0 0 {name=l17 lab=GND}
C {madvlsi/vdd.sym} 1290 -1910 0 0 {name=l18 lab=VDD}
C {madvlsi/pmos3.sym} 1040 -1770 1 0 {name=M118
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1040 -1880 1 0 {name=Mdumb22
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1540 -1770 1 0 {name=M119
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1540 -1880 1 0 {name=M120
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1040 -1650 3 0 {name=M121
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1040 -1540 3 0 {name=M122
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1010 -1510 0 0 {name=l19 lab=GND}
C {madvlsi/gnd.sym} 1010 -1620 0 0 {name=l20 lab=GND}
C {madvlsi/vdd.sym} 1010 -1910 0 0 {name=l21 lab=VDD}
C {madvlsi/vdd.sym} 1010 -1800 0 0 {name=l22 lab=VDD}
C {madvlsi/gnd.sym} 1570 -1620 0 0 {name=l23 lab=GND}
C {madvlsi/gnd.sym} 1570 -1510 0 0 {name=l24 lab=GND}
C {madvlsi/vdd.sym} 1570 -1800 0 0 {name=l25 lab=VDD}
C {madvlsi/vdd.sym} 1570 -1910 0 0 {name=l26 lab=VDD}
C {madvlsi/nmos3.sym} 1140 -1650 3 0 {name=M123
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1140 -1540 3 0 {name=M124
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1240 -1650 3 0 {name=M125
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1240 -1540 3 0 {name=M126
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1340 -1650 3 0 {name=M127
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1340 -1540 1 0 {name=M128
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1440 -1650 3 0 {name=M129
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1440 -1540 1 0 {name=M130
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1540 -1650 3 0 {name=M131
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1540 -1540 3 0 {name=M132
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1830 -1540 3 0 {name=M133
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1830 -1770 3 0 {name=M134
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1830 -1880 3 0 {name=M135
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1830 -1650 1 0 {name=M136
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1780 -1910 0 0 {name=l27 lab=VDD}
C {madvlsi/nmos3.sym} 2230 -1540 3 0 {name=M137
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2230 -1770 3 0 {name=M138
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2230 -1880 3 0 {name=M139
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2230 -1650 3 0 {name=M140
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1730 -1540 3 0 {name=M141
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1730 -1770 3 0 {name=M142
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1730 -1880 3 0 {name=M143
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1730 -1650 3 0 {name=M144
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2260 -1620 0 0 {name=l28 lab=GND}
C {madvlsi/gnd.sym} 2260 -1510 0 0 {name=l29 lab=GND}
C {madvlsi/gnd.sym} 2260 -1850 0 0 {name=l30 lab=GND}
C {madvlsi/gnd.sym} 2260 -1740 0 0 {name=l31 lab=GND}
C {madvlsi/gnd.sym} 1700 -1510 0 0 {name=l32 lab=GND}
C {madvlsi/gnd.sym} 1700 -1620 0 0 {name=l33 lab=GND}
C {madvlsi/gnd.sym} 1700 -1740 0 0 {name=l34 lab=GND}
C {madvlsi/gnd.sym} 1700 -1850 0 0 {name=l35 lab=GND}
C {madvlsi/nmos3.sym} 1930 -1540 3 0 {name=M145
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1930 -1770 3 0 {name=M146
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1930 -1880 3 0 {name=M147
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1930 -1650 1 0 {name=M148
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2030 -1540 3 0 {name=M149
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2030 -1770 3 0 {name=M150
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2030 -1880 3 0 {name=M151
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2030 -1650 1 0 {name=M152
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2130 -1540 3 0 {name=M153
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2130 -1770 3 0 {name=M154
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2130 -1880 3 0 {name=M155
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2130 -1650 1 0 {name=M156
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 2180 -1910 0 0 {name=l36 lab=VDD}
C {madvlsi/nmos3.sym} 1320 80 1 0 {name=M157
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1440 80 1 0 {name=M158
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1560 80 1 0 {name=M159
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1680 80 1 0 {name=M160
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1920 80 1 0 {name=M161
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2040 80 1 0 {name=M162
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2280 80 1 0 {name=M163
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2400 80 1 0 {name=M164
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2520 80 1 0 {name=M165
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2640 80 1 0 {name=M166
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1440 -140 1 1 {name=M167
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1560 -140 1 1 {name=M168
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1800 -140 1 1 {name=M169
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1920 -140 1 1 {name=M170
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2040 -140 1 1 {name=M171
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2160 -140 1 1 {name=M172
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2400 -140 1 1 {name=M173
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2520 -140 1 1 {name=M174
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1680 -140 1 1 {name=M175
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2280 -140 1 1 {name=M176
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1800 80 1 0 {name=M177
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2160 80 1 0 {name=M178
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2760 80 1 0 {name=M179
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2880 80 1 0 {name=M180
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3000 80 1 0 {name=M181
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3120 80 1 0 {name=M182
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3360 80 1 0 {name=M183
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3480 80 1 0 {name=M184
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3720 80 1 0 {name=M185
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3840 80 1 0 {name=M186
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3960 80 1 0 {name=M187
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4080 80 1 0 {name=M188
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3240 80 1 0 {name=M189
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3600 80 1 0 {name=M190
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2880 -140 1 1 {name=M191
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3000 -140 1 1 {name=M192
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3240 -140 1 1 {name=M193
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3360 -140 1 1 {name=M194
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3480 -140 1 1 {name=M195
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3600 -140 1 1 {name=M196
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3840 -140 1 1 {name=M197
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3960 -140 1 1 {name=M198
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3120 -140 1 1 {name=M199
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3720 -140 1 1 {name=M200
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2640 -140 1 1 {name=M201
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2760 -140 1 1 {name=M202
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1090 200 1 0 {name=l37 lab=GND}
C {madvlsi/vdd.sym} 1090 -260 3 0 {name=l38 lab=VDD}
C {madvlsi/pmos3.sym} 4080 -140 1 1 {name=M203
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4200 -140 1 1 {name=M204
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4200 80 1 0 {name=M205
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1200 80 1 0 {name=M206
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1320 -140 1 1 {name=M207
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1200 -140 1 1 {name=M208
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 940 -520 3 0 {name=X2}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 1150 -520 3 0 {name=X3}
C {madvlsi/gnd.sym} 960 -480 0 0 {name=l39 lab=GND}
C {madvlsi/gnd.sym} 1170 -480 0 0 {name=l40 lab=GND}
C {madvlsi/vsource.sym} 990 -400 0 0 {name=Vb0
value="pwl 1n 0 2u 1.8 32u 1.8 33u 0 100u 0 "}
C {madvlsi/gnd.sym} 990 -370 0 0 {name=l41 lab=GND}
C {madvlsi/vsource.sym} 1200 -400 0 0 {name=Vb1
value="pwl 32u 0 33u 1.8 63u 1.8 64u 0 100u 0"}
C {madvlsi/gnd.sym} 1200 -370 0 0 {name=l42 lab=GND}
C {madvlsi/vsource.sym} 1410 -400 0 0 {name=Vb2
value="pwl 63u 0 64u 1.8 94u 1.8 95u 0 100u 0"}
C {devices/lab_pin.sym} 920 -440 0 0 {name=l44 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 990 -520 2 0 {name=l45 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} 1200 -520 1 0 {name=l46 sig_type=std_logic lab=s1}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 1360 -520 3 0 {name=X5}
C {madvlsi/gnd.sym} 1380 -480 0 0 {name=l48 lab=GND}
C {madvlsi/vsource.sym} 1600 -400 0 0 {name=Vb3
value="pwl 93u 0 94u 1.8 124u 1.8 125u 0 200u 0"}
C {madvlsi/gnd.sym} 1410 -370 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} 1410 -520 2 0 {name=l55 sig_type=std_logic lab=s2}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 1550 -520 3 0 {name=X6}
C {madvlsi/gnd.sym} 1570 -480 0 0 {name=l62 lab=GND}
C {madvlsi/vsource.sym} 1790 -400 0 0 {name=Vb4
value="pwl 123u 0 124u 1.8 154u 1.8 155u 0 200u 0"}
C {madvlsi/gnd.sym} 1600 -370 0 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} 1600 -520 2 0 {name=l85 sig_type=std_logic lab=s3}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 1740 -520 3 0 {name=X7}
C {madvlsi/gnd.sym} 1760 -480 0 0 {name=l88 lab=GND}
C {madvlsi/vsource.sym} 1980 -400 0 0 {name=Vb5
value="pwl 183u 0 184u 1.8 214u 1.8 215u 0 220u 0"}
C {madvlsi/gnd.sym} 1790 -370 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} 1790 -520 2 0 {name=l93 sig_type=std_logic lab=s4}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 1930 -520 3 0 {name=X8}
C {madvlsi/gnd.sym} 1950 -480 0 0 {name=l96 lab=GND}
C {madvlsi/gnd.sym} 1980 -370 0 0 {name=l97 lab=GND}
C {devices/lab_pin.sym} 1980 -520 2 0 {name=l101 sig_type=std_logic lab=s5}
C {madvlsi/vsource.sym} 2170 -400 0 0 {name=Vb6
value="pwl 213u 0 214u 1.8 244u 1.8 245u 0 260u 0"}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 2120 -520 3 0 {name=X4}
C {madvlsi/gnd.sym} 2140 -480 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} 2170 -520 2 0 {name=l52 sig_type=std_logic lab=s6}
C {madvlsi/gnd.sym} 2170 -370 0 0 {name=l53 lab=GND}
C {madvlsi/resistor.sym} 1000 190 0 0 {name=R1
value=400k
m=1}
C {madvlsi/gnd.sym} 1000 220 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 1140 -1450 0 0 {name=l15 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 3430 -630 3 0 {name=l12 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 4410 260 2 0 {name=l2 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 4410 -60 2 0 {name=l47 sig_type=std_logic lab=Vbp}
C {madvlsi/vsource.sym} 2770 -1610 1 0 {name=Vout
value=1}
C {madvlsi/gnd.sym} 2740 -1610 1 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} 2350 -1710 2 0 {name=l51 sig_type=std_logic lab=Vg}
C {devices/lab_pin.sym} 630 -1280 0 0 {name=l54 sig_type=std_logic lab=Vg}
