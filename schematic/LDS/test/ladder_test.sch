v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
L 4 1950 -920 1950 -790 {}
L 4 1950 -790 2120 -790 {}
L 4 2120 -920 2120 -790 {}
L 4 1950 -920 2120 -920 {}
L 4 1750 -900 1750 -800 {}
L 4 1750 -800 1930 -800 {}
L 4 1930 -910 1930 -800 {}
L 4 1750 -910 1930 -910 {}
L 4 1750 -910 1750 -890 {}
L 4 2250 -920 2250 -790 {}
L 4 2250 -790 2420 -790 {}
L 4 2420 -920 2420 -790 {}
L 4 2250 -920 2420 -920 {}
L 4 2450 -920 2450 -790 {}
L 4 2450 -790 2620 -790 {}
L 4 2620 -920 2620 -790 {}
L 4 2450 -920 2620 -920 {}
L 4 2750 -920 2750 -790 {}
L 4 2750 -790 2920 -790 {}
L 4 2920 -920 2920 -790 {}
L 4 2750 -920 2920 -920 {}
L 4 2950 -920 2950 -790 {}
L 4 2950 -790 3120 -790 {}
L 4 3120 -920 3120 -790 {}
L 4 2950 -920 3120 -920 {}
L 4 4470 -290 4470 -160 {}
L 4 4470 -160 4640 -160 {}
L 4 4640 -290 4640 -160 {}
L 4 4470 -290 4640 -290 {}
L 4 4270 -270 4270 -170 {}
L 4 4270 -170 4450 -170 {}
L 4 4450 -280 4450 -170 {}
L 4 4270 -280 4450 -280 {}
L 4 4270 -280 4270 -260 {}
L 4 4770 -290 4770 -160 {}
L 4 4770 -160 4940 -160 {}
L 4 4940 -290 4940 -160 {}
L 4 4770 -290 4940 -290 {}
L 4 4970 -290 4970 -160 {}
L 4 4970 -160 5140 -160 {}
L 4 5140 -290 5140 -160 {}
L 4 4970 -290 5140 -290 {}
L 4 5270 -290 5270 -160 {}
L 4 5270 -160 5440 -160 {}
L 4 5440 -290 5440 -160 {}
L 4 5270 -290 5440 -290 {}
L 4 5470 -290 5470 -160 {}
L 4 5470 -160 5640 -160 {}
L 4 5640 -290 5640 -160 {}
L 4 5470 -290 5640 -290 {}
N 1820 -1080 1860 -1080 { lab=VDD}
N 1920 -1080 1960 -1080 { lab=Vb0}
N 2020 -1080 2060 -1080 { lab=Vb1}
N 2120 -1080 2160 -1080 { lab=VDD}
N 2220 -1080 2260 -1080 { lab=VDD}
N 2320 -1080 2360 -1080 { lab=Vb2}
N 2420 -1080 2460 -1080 { lab=Vb3}
N 2520 -1080 2560 -1080 { lab=VDD}
N 2620 -1080 2660 -1080 { lab=Vb4}
N 2720 -1080 2760 -1080 { lab=VDD}
N 2820 -1080 2860 -1080 { lab=Vb5}
N 2920 -1080 2960 -1080 { lab=VDD}
N 3020 -1080 3060 -1080 { lab=Vb6}
N 3120 -1080 3160 -1080 { lab=#net1}
N 1820 -850 1860 -850 { lab=Vb0}
N 1920 -850 1960 -850 { lab=Vb1}
N 2020 -850 2060 -850 { lab=Vb2}
N 2120 -850 2160 -850 { lab=Vb1}
N 2220 -850 2260 -850 { lab=Vb3}
N 2320 -850 2360 -850 { lab=Vb2}
N 2420 -850 2460 -850 { lab=Vb3}
N 2520 -850 2560 -850 { lab=Vb4}
N 2620 -850 2660 -850 { lab=Vb3}
N 2720 -850 2760 -850 { lab=Vb5}
N 2820 -850 2860 -850 { lab=Vb4}
N 2920 -850 2960 -850 { lab=Vb5}
N 3020 -850 3060 -850 { lab=Vb6}
N 2020 -640 2060 -640 { lab=Vb0}
N 2120 -640 2160 -640 { lab=Vb1}
N 2220 -640 2260 -640 { lab=GND}
N 2320 -640 2360 -640 { lab=Vb2}
N 2420 -640 2460 -640 { lab=Vb3}
N 2520 -640 2560 -640 { lab=GND}
N 2620 -640 2660 -640 { lab=Vb4}
N 2720 -640 2760 -640 { lab=Vb5}
N 2820 -640 2860 -640 { lab=GND}
N 1620 -540 3480 -540 { lab=GND}
N 1940 -640 1940 -540 { lab=GND}
N 1990 -610 1990 -500 { lab=b0}
N 2190 -610 2190 -510 { lab=b1}
N 2290 -610 2290 -510 { lab=b2}
N 2490 -610 2490 -510 { lab=b3}
N 2590 -610 2590 -510 { lab=b4}
N 2790 -610 2790 -510 { lab=b5}
N 2890 -610 2890 -510 { lab=b6}
N 1580 -1140 3440 -1140 { lab=Vg}
N 2090 -610 2090 -540 { lab=GND}
N 2390 -610 2390 -540 { lab=GND}
N 2690 -610 2690 -540 { lab=GND}
N 2840 -640 2840 -540 { lab=GND}
N 2240 -640 2240 -540 { lab=GND}
N 2540 -640 2540 -540 { lab=GND}
N 1790 -1140 1790 -1110 { lab=Vg}
N 1890 -1140 1890 -1110 { lab=Vg}
N 2090 -1140 2090 -1110 { lab=Vg}
N 2290 -1140 2290 -1110 { lab=Vg}
N 2490 -1140 2490 -1110 { lab=Vg}
N 2690 -1140 2690 -1110 { lab=Vg}
N 2890 -1140 2890 -1110 { lab=Vg}
N 3090 -1140 3090 -1110 { lab=Vg}
N 3190 -1140 3190 -1110 { lab=Vg}
N 1740 -1080 1740 -1020 { lab=Vb0}
N 1740 -1020 1940 -1020 { lab=Vb0}
N 1940 -1080 1940 -1020 { lab=Vb0}
N 3040 -1080 3040 -1020 { lab=Vb6}
N 3040 -1020 3240 -1020 { lab=Vb6}
N 3240 -1080 3240 -1020 { lab=Vb6}
N 1990 -1110 1990 -1000 { lab=GND}
N 2190 -1110 2190 -1000 { lab=GND}
N 2390 -1110 2390 -1000 { lab=GND}
N 2590 -1110 2590 -1000 { lab=GND}
N 2790 -1110 2790 -1000 { lab=GND}
N 2990 -1110 2990 -1000 { lab=GND}
N 1560 -1000 2990 -1000 { lab=GND}
N 1560 -540 1620 -540 { lab=GND}
N 1740 -850 1740 -780 { lab=Vb1}
N 1740 -780 2140 -780 { lab=Vb1}
N 2140 -850 2140 -780 { lab=Vb1}
N 2740 -850 2740 -780 { lab=Vb5}
N 2740 -780 3140 -780 { lab=Vb5}
N 3140 -850 3140 -780 { lab=Vb5}
N 2240 -850 2240 -780 { lab=Vb3}
N 2240 -780 2640 -780 { lab=Vb3}
N 2640 -850 2640 -780 { lab=Vb3}
N 2190 -1000 2190 -880 { lab=GND}
N 2690 -1000 2690 -880 { lab=GND}
N 1790 -890 1790 -880 { lab=Vg}
N 1790 -890 3090 -890 { lab=Vg}
N 3090 -890 3090 -880 { lab=Vg}
N 2990 -890 2990 -880 { lab=Vg}
N 2890 -890 2890 -880 { lab=Vg}
N 2790 -890 2790 -880 { lab=Vg}
N 2590 -890 2590 -880 { lab=Vg}
N 2490 -890 2490 -880 { lab=Vg}
N 2390 -890 2390 -880 { lab=Vg}
N 2290 -890 2290 -880 { lab=Vg}
N 2090 -890 2090 -880 { lab=Vg}
N 1990 -890 1990 -880 { lab=Vg}
N 1890 -890 1890 -880 { lab=Vg}
N 1840 -1240 1840 -1080 { lab=VDD}
N 1580 -890 1790 -890 { lab=Vg}
N 1840 -1020 1840 -850 { lab=Vb0}
N 1840 -850 1840 -710 { lab=Vb0}
N 1840 -710 2040 -710 { lab=Vb0}
N 2040 -710 2040 -640 { lab=Vb0}
N 1940 -850 1940 -780 { lab=Vb1}
N 1940 -970 1940 -850 { lab=Vb1}
N 1940 -970 2040 -970 { lab=Vb1}
N 2040 -1080 2040 -970 { lab=Vb1}
N 2140 -1240 2140 -1080 { lab=VDD}
N 1940 -780 1940 -730 { lab=Vb1}
N 1940 -730 2140 -730 { lab=Vb1}
N 2140 -730 2140 -640 { lab=Vb1}
N 2240 -1240 2240 -1080 { lab=VDD}
N 3140 -1160 3140 -1080 { lab=#net1}
N 3140 -1160 3440 -1160 { lab=#net1}
N 2340 -1080 2340 -950 { lab=Vb2}
N 2040 -950 2340 -950 { lab=Vb2}
N 2040 -950 2040 -850 { lab=Vb2}
N 2340 -950 2340 -850 { lab=Vb2}
N 2540 -1240 2540 -1080 { lab=VDD}
N 2340 -850 2340 -640 { lab=Vb2}
N 3040 -850 3040 -720 { lab=Vb6}
N 3040 -1020 3040 -850 { lab=Vb6}
N 2840 -1080 2840 -970 { lab=Vb5}
N 2840 -970 2940 -970 { lab=Vb5}
N 2940 -970 2940 -850 { lab=Vb5}
N 2940 -850 2940 -780 { lab=Vb5}
N 2740 -780 2740 -640 { lab=Vb5}
N 2640 -930 2840 -930 { lab=Vb4}
N 2840 -930 2840 -850 { lab=Vb4}
N 2840 -850 2840 -740 { lab=Vb4}
N 2640 -740 2840 -740 { lab=Vb4}
N 2640 -740 2640 -640 { lab=Vb4}
N 2440 -1080 2440 -850 { lab=Vb3}
N 2440 -850 2440 -780 { lab=Vb3}
N 2440 -780 2440 -640 { lab=Vb3}
N 2540 -850 2540 -740 { lab=Vb4}
N 2540 -740 2640 -740 { lab=Vb4}
N 1520 -1140 1580 -1140 { lab=Vg}
N 1520 -1140 1520 -890 { lab=Vg}
N 1520 -890 1580 -890 { lab=Vg}
N 1540 -1000 1560 -1000 { lab=GND}
N 1540 -1000 1540 -540 { lab=GND}
N 1540 -540 1560 -540 { lab=GND}
N 2640 -1080 2640 -930 { lab=Vb4}
N 1590 -1110 1690 -1110 { lab=GND}
N 1620 -1080 1660 -1080 { lab=GND}
N 1560 -1110 1560 -1080 { lab=GND}
N 1560 -1110 1590 -1110 { lab=GND}
N 1640 -1110 1640 -1080 { lab=GND}
N 1720 -1080 1760 -1080 { lab=Vb0}
N 1640 -1080 1640 -1000 { lab=GND}
N 3220 -1080 3260 -1080 { lab=Vb6}
N 3290 -1110 3390 -1110 { lab=GND}
N 3390 -1110 3420 -1110 { lab=GND}
N 3420 -1110 3420 -1080 { lab=GND}
N 3320 -1080 3360 -1080 { lab=GND}
N 3340 -1110 3340 -1080 { lab=GND}
N 2990 -1000 3340 -1000 { lab=GND}
N 3340 -1080 3340 -1000 { lab=GND}
N 1720 -850 1760 -850 { lab=Vb1}
N 1590 -880 1690 -880 { lab=GND}
N 1560 -880 1590 -880 { lab=GND}
N 1560 -880 1560 -850 { lab=GND}
N 1620 -850 1660 -850 { lab=GND}
N 1640 -880 1640 -850 { lab=GND}
N 1540 -850 1560 -850 { lab=GND}
N 1620 -640 1660 -640 { lab=GND}
N 1720 -640 1760 -640 { lab=GND}
N 1820 -640 1860 -640 { lab=GND}
N 1920 -640 1960 -640 { lab=GND}
N 1560 -610 1890 -610 { lab=GND}
N 1560 -640 1560 -610 { lab=GND}
N 1640 -640 1640 -610 { lab=GND}
N 1740 -640 1740 -610 { lab=GND}
N 1840 -640 1840 -610 { lab=GND}
N 1740 -610 1740 -540 { lab=GND}
N 2940 -720 2940 -640 { lab=Vb6}
N 2940 -720 3040 -720 { lab=Vb6}
N 2920 -640 2960 -640 { lab=Vb6}
N 2990 -610 3420 -610 { lab=GND}
N 3420 -640 3420 -610 { lab=GND}
N 3320 -640 3360 -640 { lab=GND}
N 3220 -640 3260 -640 { lab=GND}
N 3120 -640 3160 -640 { lab=GND}
N 3020 -640 3060 -640 { lab=GND}
N 3040 -640 3040 -610 { lab=GND}
N 3140 -640 3140 -610 { lab=GND}
N 3240 -640 3240 -610 { lab=GND}
N 3340 -640 3340 -610 { lab=GND}
N 3190 -610 3190 -540 { lab=GND}
N 3120 -850 3160 -850 { lab=Vb5}
N 3220 -850 3260 -850 { lab=GND}
N 3320 -850 3360 -850 { lab=GND}
N 3190 -880 3420 -880 { lab=GND}
N 3420 -880 3420 -850 { lab=GND}
N 3340 -880 3340 -850 { lab=GND}
N 3240 -880 3240 -850 { lab=GND}
N 3340 -1000 3340 -880 { lab=GND}
N 1520 -1240 3480 -1240 { lab=VDD}
N 1520 -1260 1520 -1240 { lab=VDD}
N 1540 -540 1540 -500 { lab=GND}
N 2940 -1240 2940 -1080 { lab=VDD}
N 2740 -1240 2740 -1080 { lab=VDD}
N 2890 -510 3010 -510 { lab=b6}
N 3010 -510 3010 -420 { lab=b6}
N 2820 -510 2820 -420 { lab=b5}
N 2630 -510 2630 -420 { lab=b4}
N 2440 -510 2440 -420 { lab=b3}
N 2250 -510 2250 -420 { lab=b2}
N 2040 -510 2040 -420 { lab=b1}
N 1830 -500 1830 -420 { lab=b0}
N 1830 -500 1990 -500 { lab=b0}
N 1480 -1140 1520 -1140 { lab=Vg}
N 3450 -1160 3470 -1160 { lab=#net1}
N 3440 -1160 3450 -1160 { lab=#net1}
N 2080 -380 2090 -380 { lab=s1}
N 2090 -380 2090 -290 { lab=s1}
N 1870 -380 1880 -380 { lab=s0}
N 1880 -380 1880 -290 { lab=s0}
N 1920 -300 2020 -300 { lab=Vbn}
N 2020 -300 2120 -300 { lab=Vbn}
N 1810 -340 1810 -300 { lab=Vbn}
N 2020 -340 2020 -300 { lab=Vbn}
N 2290 -380 2300 -380 { lab=s2}
N 2300 -380 2300 -290 { lab=s2}
N 2230 -300 2420 -300 { lab=Vbn}
N 2230 -340 2230 -300 { lab=Vbn}
N 2480 -380 2490 -380 { lab=s3}
N 2490 -380 2490 -290 { lab=s3}
N 2420 -300 2610 -300 { lab=Vbn}
N 2420 -340 2420 -300 { lab=Vbn}
N 2670 -380 2680 -380 { lab=s4}
N 2680 -380 2680 -290 { lab=s4}
N 2610 -300 2800 -300 { lab=Vbn}
N 2610 -340 2610 -300 { lab=Vbn}
N 2860 -380 2870 -380 { lab=s5}
N 2870 -380 2870 -290 { lab=s5}
N 2800 -300 2990 -300 { lab=Vbn}
N 2800 -340 2800 -300 { lab=Vbn}
N 2120 -300 2230 -300 { lab=Vbn}
N 2990 -340 2990 -300 { lab=Vbn}
N 3050 -380 3060 -380 { lab=s6}
N 3060 -380 3060 -290 { lab=s6}
N 1810 -300 1920 -300 { lab=Vbn}
N 2790 -510 2820 -510 { lab=b5}
N 2590 -510 2630 -510 { lab=b4}
N 2440 -510 2490 -510 { lab=b3}
N 2250 -510 2290 -510 { lab=b2}
N 2040 -510 2190 -510 { lab=b1}
N 1610 -240 1730 -240 { lab=Vbn}
N 1700 -240 1700 -210 { lab=Vbn}
N 5000 -1030 5000 -1010 { lab=#net2}
N 5000 -1010 5200 -1010 { lab=#net2}
N 5200 -1030 5200 -1010 { lab=#net2}
N 5100 -1030 5100 -1010 { lab=#net2}
N 4930 -1060 4970 -1060 { lab=#net3}
N 5030 -1060 5070 -1060 { lab=VDD}
N 5130 -1060 5170 -1060 { lab=#net4}
N 4850 -1060 4850 -1010 { lab=#net5}
N 4850 -1010 4850 -940 { lab=#net5}
N 4950 -1060 4950 -900 { lab=#net3}
N 5200 -1010 5250 -1010 { lab=#net2}
N 5250 -1060 5270 -1060 { lab=#net2}
N 5250 -1010 5500 -1010 { lab=#net2}
N 5500 -1030 5500 -1010 { lab=#net2}
N 5400 -1030 5400 -1010 { lab=#net2}
N 5300 -1030 5300 -1010 { lab=#net2}
N 5330 -1060 5370 -1060 { lab=#net4}
N 5430 -1060 5470 -1060 { lab=VDD}
N 5530 -1060 5570 -1060 { lab=#net3}
N 5650 -1060 5650 -1010 { lab=#net5}
N 5650 -1010 5650 -940 { lab=#net5}
N 5550 -1060 5550 -900 { lab=#net3}
N 5230 -1060 5250 -1060 { lab=#net2}
N 4800 -1250 4800 -1030 { lab=VDD}
N 5700 -1250 5700 -1030 { lab=VDD}
N 4630 -1060 4670 -1060 { lab=#net6}
N 4650 -1060 4650 -980 { lab=#net6}
N 4730 -1060 4770 -1060 { lab=#net4}
N 4830 -1060 4870 -1060 { lab=#net5}
N 4700 -1030 4700 -1010 { lab=#net5}
N 4700 -1010 4870 -1010 { lab=#net5}
N 4870 -1010 4900 -1010 { lab=#net5}
N 4900 -1030 4900 -1010 { lab=#net5}
N 5630 -1060 5670 -1060 { lab=#net5}
N 5730 -1060 5770 -1060 { lab=#net4}
N 5600 -1030 5600 -1010 { lab=#net5}
N 5600 -1010 5650 -1010 { lab=#net5}
N 5650 -1010 5800 -1010 { lab=#net5}
N 5800 -1030 5800 -1010 { lab=#net5}
N 5830 -1060 5870 -1060 { lab=#net6}
N 5850 -1060 5850 -980 { lab=#net6}
N 4750 -1160 4750 -1060 { lab=#net4}
N 4750 -1160 5750 -1160 { lab=#net4}
N 5750 -1160 5750 -1060 { lab=#net4}
N 5350 -1160 5350 -1060 { lab=#net4}
N 5150 -1160 5150 -1060 { lab=#net4}
N 5050 -1250 5050 -1060 { lab=VDD}
N 5450 -1250 5450 -1060 { lab=VDD}
N 4850 -940 4850 -870 { lab=#net5}
N 5650 -940 5650 -870 { lab=#net5}
N 4850 -870 5650 -870 { lab=#net5}
N 4530 -1060 4570 -1060 { lab=VDD}
N 4600 -1030 4600 -1010 { lab=VDD}
N 4550 -1060 4550 -1010 { lab=VDD}
N 4550 -1250 4550 -1060 { lab=VDD}
N 5900 -1030 5900 -1010 { lab=VDD}
N 5900 -1010 5950 -1010 { lab=VDD}
N 5950 -1060 5950 -1010 { lab=VDD}
N 5930 -1060 5970 -1060 { lab=VDD}
N 5950 -1250 5950 -1060 { lab=VDD}
N 4120 -1250 6300 -1250 { lab=VDD}
N 4250 -1060 4270 -1060 { lab=VDD}
N 4250 -1060 4250 -1010 { lab=VDD}
N 4250 -1010 4600 -1010 { lab=VDD}
N 4330 -1060 4370 -1060 { lab=VDD}
N 4430 -1060 4470 -1060 { lab=VDD}
N 4450 -1060 4450 -1010 { lab=VDD}
N 4350 -1060 4350 -1010 { lab=VDD}
N 4400 -1030 4400 -1010 { lab=VDD}
N 4300 -1030 4300 -1010 { lab=VDD}
N 4500 -1030 4500 -1010 { lab=VDD}
N 6000 -1030 6000 -1010 { lab=VDD}
N 6000 -1010 6150 -1010 { lab=VDD}
N 6150 -1060 6150 -1010 { lab=VDD}
N 6130 -1060 6150 -1060 { lab=VDD}
N 6100 -1030 6100 -1010 { lab=VDD}
N 6030 -1060 6070 -1060 { lab=VDD}
N 6050 -1060 6050 -1010 { lab=VDD}
N 5950 -1010 6000 -1010 { lab=VDD}
N 5250 -1060 5250 -810 { lab=#net2}
N 3950 -980 3950 -970 { lab=#net6}
N 3950 -880 3950 -860 { lab=GND}
N 3950 -860 3950 -850 { lab=GND}
N 3950 -970 3950 -960 { lab=#net6}
N 3950 -950 3950 -940 { lab=#net7}
N 4340 -450 4380 -450 { lab=VDD}
N 4440 -450 4480 -450 { lab=Vb0}
N 4540 -450 4580 -450 { lab=Vb1}
N 4640 -450 4680 -450 { lab=VDD}
N 4740 -450 4780 -450 { lab=VDD}
N 4840 -450 4880 -450 { lab=Vb2}
N 4940 -450 4980 -450 { lab=Vb3}
N 5040 -450 5080 -450 { lab=VDD}
N 5140 -450 5180 -450 { lab=Vb4}
N 5240 -450 5280 -450 { lab=VDD}
N 5340 -450 5380 -450 { lab=Vb5}
N 5440 -450 5480 -450 { lab=#net2}
N 5540 -450 5580 -450 { lab=Vb6}
N 5640 -450 5680 -450 { lab=#net5}
N 4340 -220 4380 -220 { lab=Vb0}
N 4440 -220 4480 -220 { lab=Vb1}
N 4540 -220 4580 -220 { lab=Vb2}
N 4640 -220 4680 -220 { lab=Vb1}
N 4740 -220 4780 -220 { lab=Vb3}
N 4840 -220 4880 -220 { lab=Vb2}
N 4940 -220 4980 -220 { lab=Vb3}
N 5040 -220 5080 -220 { lab=Vb4}
N 5140 -220 5180 -220 { lab=Vb3}
N 5240 -220 5280 -220 { lab=Vb5}
N 5340 -220 5380 -220 { lab=Vb4}
N 5440 -220 5480 -220 { lab=Vb5}
N 5540 -220 5580 -220 { lab=Vb6}
N 4540 -10 4580 -10 { lab=Vb0}
N 4640 -10 4680 -10 { lab=Vb1}
N 4740 -10 4780 -10 { lab=GND}
N 4840 -10 4880 -10 { lab=Vb2}
N 4940 -10 4980 -10 { lab=Vb3}
N 5040 -10 5080 -10 { lab=GND}
N 5140 -10 5180 -10 { lab=Vb4}
N 5240 -10 5280 -10 { lab=Vb5}
N 5340 -10 5380 -10 { lab=GND}
N 4140 90 6000 90 { lab=GND}
N 4460 -10 4460 90 { lab=GND}
N 4100 -510 5960 -510 { lab=Vg}
N 4610 20 4610 90 { lab=GND}
N 4910 20 4910 90 { lab=GND}
N 5210 20 5210 90 { lab=GND}
N 5360 -10 5360 90 { lab=GND}
N 4760 -10 4760 90 { lab=GND}
N 5060 -10 5060 90 { lab=GND}
N 4310 -510 4310 -480 { lab=Vg}
N 4410 -510 4410 -480 { lab=Vg}
N 4610 -510 4610 -480 { lab=Vg}
N 4810 -510 4810 -480 { lab=Vg}
N 5010 -510 5010 -480 { lab=Vg}
N 5210 -510 5210 -480 { lab=Vg}
N 5410 -510 5410 -480 { lab=Vg}
N 5610 -510 5610 -480 { lab=Vg}
N 5710 -510 5710 -480 { lab=Vg}
N 4260 -450 4260 -390 { lab=Vb0}
N 4260 -390 4460 -390 { lab=Vb0}
N 4460 -450 4460 -390 { lab=Vb0}
N 5560 -450 5560 -390 { lab=Vb6}
N 5560 -390 5760 -390 { lab=Vb6}
N 5760 -450 5760 -390 { lab=Vb6}
N 4510 -480 4510 -370 { lab=GND}
N 4710 -480 4710 -370 { lab=GND}
N 4910 -480 4910 -370 { lab=GND}
N 5110 -480 5110 -370 { lab=GND}
N 5310 -480 5310 -370 { lab=GND}
N 5510 -480 5510 -370 { lab=GND}
N 4080 -370 5510 -370 { lab=GND}
N 4080 90 4140 90 { lab=GND}
N 4260 -220 4260 -150 { lab=Vb1}
N 4260 -150 4660 -150 { lab=Vb1}
N 4660 -220 4660 -150 { lab=Vb1}
N 5260 -220 5260 -150 { lab=Vb5}
N 5260 -150 5660 -150 { lab=Vb5}
N 5660 -220 5660 -150 { lab=Vb5}
N 4760 -220 4760 -150 { lab=Vb3}
N 4760 -150 5160 -150 { lab=Vb3}
N 5160 -220 5160 -150 { lab=Vb3}
N 4710 -370 4710 -250 { lab=GND}
N 5210 -370 5210 -250 { lab=GND}
N 4310 -260 4310 -250 { lab=Vg}
N 4310 -260 5610 -260 { lab=Vg}
N 5610 -260 5610 -250 { lab=Vg}
N 5510 -260 5510 -250 { lab=Vg}
N 5410 -260 5410 -250 { lab=Vg}
N 5310 -260 5310 -250 { lab=Vg}
N 5110 -260 5110 -250 { lab=Vg}
N 5010 -260 5010 -250 { lab=Vg}
N 4910 -260 4910 -250 { lab=Vg}
N 4810 -260 4810 -250 { lab=Vg}
N 4610 -260 4610 -250 { lab=Vg}
N 4510 -260 4510 -250 { lab=Vg}
N 4410 -260 4410 -250 { lab=Vg}
N 4360 -610 4360 -450 { lab=VDD}
N 4100 -260 4310 -260 { lab=Vg}
N 4360 -390 4360 -220 { lab=Vb0}
N 4360 -220 4360 -80 { lab=Vb0}
N 4360 -80 4560 -80 { lab=Vb0}
N 4560 -80 4560 -10 { lab=Vb0}
N 4460 -220 4460 -150 { lab=Vb1}
N 4460 -340 4460 -220 { lab=Vb1}
N 4460 -340 4560 -340 { lab=Vb1}
N 4560 -450 4560 -340 { lab=Vb1}
N 4660 -610 4660 -450 { lab=VDD}
N 4460 -150 4460 -100 { lab=Vb1}
N 4460 -100 4660 -100 { lab=Vb1}
N 4660 -100 4660 -10 { lab=Vb1}
N 4760 -610 4760 -450 { lab=VDD}
N 5660 -530 5660 -450 { lab=#net5}
N 4860 -450 4860 -320 { lab=Vb2}
N 4560 -320 4860 -320 { lab=Vb2}
N 4560 -320 4560 -220 { lab=Vb2}
N 4860 -320 4860 -220 { lab=Vb2}
N 5060 -610 5060 -450 { lab=VDD}
N 4860 -220 4860 -10 { lab=Vb2}
N 5560 -220 5560 -90 { lab=Vb6}
N 5560 -390 5560 -220 { lab=Vb6}
N 5360 -450 5360 -340 { lab=Vb5}
N 5360 -340 5460 -340 { lab=Vb5}
N 5460 -340 5460 -220 { lab=Vb5}
N 5460 -220 5460 -150 { lab=Vb5}
N 5260 -150 5260 -10 { lab=Vb5}
N 5160 -300 5360 -300 { lab=Vb4}
N 5360 -300 5360 -220 { lab=Vb4}
N 5360 -220 5360 -110 { lab=Vb4}
N 5160 -110 5360 -110 { lab=Vb4}
N 5160 -110 5160 -10 { lab=Vb4}
N 4960 -450 4960 -220 { lab=Vb3}
N 4960 -220 4960 -150 { lab=Vb3}
N 4960 -150 4960 -10 { lab=Vb3}
N 5060 -220 5060 -110 { lab=Vb4}
N 5060 -110 5160 -110 { lab=Vb4}
N 4040 -510 4100 -510 { lab=Vg}
N 4040 -510 4040 -260 { lab=Vg}
N 4040 -260 4100 -260 { lab=Vg}
N 4060 -370 4080 -370 { lab=GND}
N 4060 -370 4060 90 { lab=GND}
N 4060 90 4080 90 { lab=GND}
N 5160 -450 5160 -300 { lab=Vb4}
N 4110 -480 4210 -480 { lab=GND}
N 4140 -450 4180 -450 { lab=GND}
N 4080 -480 4080 -450 { lab=GND}
N 4080 -480 4110 -480 { lab=GND}
N 4160 -480 4160 -450 { lab=GND}
N 4240 -450 4280 -450 { lab=Vb0}
N 4160 -450 4160 -370 { lab=GND}
N 5740 -450 5780 -450 { lab=Vb6}
N 5810 -480 5910 -480 { lab=GND}
N 5910 -480 5940 -480 { lab=GND}
N 5940 -480 5940 -450 { lab=GND}
N 5840 -450 5880 -450 { lab=GND}
N 5860 -480 5860 -450 { lab=GND}
N 5510 -370 5860 -370 { lab=GND}
N 5860 -450 5860 -370 { lab=GND}
N 4240 -220 4280 -220 { lab=Vb1}
N 4110 -250 4210 -250 { lab=GND}
N 4080 -250 4110 -250 { lab=GND}
N 4080 -250 4080 -220 { lab=GND}
N 4140 -220 4180 -220 { lab=GND}
N 4160 -250 4160 -220 { lab=GND}
N 4060 -220 4080 -220 { lab=GND}
N 4140 -10 4180 -10 { lab=GND}
N 4240 -10 4280 -10 { lab=GND}
N 4340 -10 4380 -10 { lab=GND}
N 4440 -10 4480 -10 { lab=GND}
N 4080 20 4410 20 { lab=GND}
N 4080 -10 4080 20 { lab=GND}
N 4160 -10 4160 20 { lab=GND}
N 4260 -10 4260 20 { lab=GND}
N 4360 -10 4360 20 { lab=GND}
N 4260 20 4260 90 { lab=GND}
N 5460 -90 5460 -10 { lab=Vb6}
N 5460 -90 5560 -90 { lab=Vb6}
N 5440 -10 5480 -10 { lab=Vb6}
N 5510 20 5940 20 { lab=GND}
N 5940 -10 5940 20 { lab=GND}
N 5840 -10 5880 -10 { lab=GND}
N 5740 -10 5780 -10 { lab=GND}
N 5640 -10 5680 -10 { lab=GND}
N 5540 -10 5580 -10 { lab=GND}
N 5560 -10 5560 20 { lab=GND}
N 5660 -10 5660 20 { lab=GND}
N 5760 -10 5760 20 { lab=GND}
N 5860 -10 5860 20 { lab=GND}
N 5710 20 5710 90 { lab=GND}
N 5640 -220 5680 -220 { lab=Vb5}
N 5740 -220 5780 -220 { lab=GND}
N 5840 -220 5880 -220 { lab=GND}
N 5710 -250 5940 -250 { lab=GND}
N 5940 -250 5940 -220 { lab=GND}
N 5860 -250 5860 -220 { lab=GND}
N 5760 -250 5760 -220 { lab=GND}
N 5860 -370 5860 -250 { lab=GND}
N 4040 -610 6000 -610 { lab=VDD}
N 4040 -630 4040 -610 { lab=VDD}
N 4060 90 4060 130 { lab=GND}
N 5260 -610 5260 -450 { lab=VDD}
N 5410 20 5410 90 { lab=GND}
N 5310 20 5310 90 { lab=GND}
N 5110 20 5110 90 { lab=GND}
N 5010 20 5010 90 { lab=GND}
N 4810 20 4810 90 { lab=GND}
N 4710 20 4710 90 { lab=GND}
N 5650 -870 5650 -640 { lab=#net5}
N 5650 -640 5660 -640 { lab=#net5}
N 5250 -810 5460 -810 { lab=#net2}
N 3750 -1160 4070 -1160 { lab=#net3}
N 4070 -1160 4070 -900 { lab=#net3}
N 3950 -980 5850 -980 { lab=#net6}
N 3470 -1160 3740 -1160 { lab=#net1}
N 5660 -640 5660 -530 { lab=#net5}
N 5460 -800 5460 -450 { lab=#net2}
N 5460 -810 5460 -800 { lab=#net2}
N 4070 -900 5550 -900 { lab=#net3}
C {madvlsi/nmos3.sym} 1790 -1080 1 0 {name=M3a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1890 -1080 1 0 {name=M3b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1990 -1080 1 0 {name=Mdumb14
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2090 -1080 1 0 {name=M5
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2190 -1080 1 0 {name=Mdumb15
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2290 -1080 1 0 {name=M7
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2390 -1080 1 0 {name=Mdumb17
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2490 -1080 1 0 {name=M9
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2590 -1080 1 0 {name=Mdumb18
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2690 -1080 1 0 {name=M11
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2790 -1080 1 0 {name=Mdumb20
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2890 -1080 1 0 {name=M13
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2990 -1080 1 0 {name=Mdumb21
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3090 -1080 1 0 {name=M15a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3190 -1080 1 0 {name=M15b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1790 -850 1 0 {name=M20a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1890 -850 1 0 {name=M20b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1990 -850 1 0 {name=M21a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2090 -850 1 0 {name=M21b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2190 -850 1 0 {name=Mdumb16
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2290 -850 1 0 {name=M23a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2390 -850 1 0 {name=M23b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2490 -850 1 0 {name=M24a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2590 -850 1 0 {name=M24b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2690 -850 1 0 {name=Mdumb19
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2790 -850 1 0 {name=M26a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2890 -850 1 0 {name=M26b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2990 -850 1 0 {name=M27a
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3090 -850 1 0 {name=M27b
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1990 -640 3 0 {name=M35
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2090 -640 3 0 {name=Mdumb26
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2190 -640 3 0 {name=M37
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2290 -640 3 0 {name=M38
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2390 -640 3 0 {name=Mdumb27
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2490 -640 3 0 {name=M40
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2590 -640 3 0 {name=M41
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2690 -640 3 0 {name=Mdumb28
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2790 -640 3 0 {name=M43
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2890 -640 3 0 {name=M44
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3290 -1080 1 0 {name=Mdumb22
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3390 -1080 1 0 {name=Mdumb23
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1690 -1080 1 0 {name=Mdumb13
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1590 -1080 1 0 {name=Mdumb12
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1690 -850 1 0 {name=Mdumb11
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1590 -850 1 0 {name=Mdumb10
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3190 -850 1 0 {name=Mdumb24
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3290 -850 1 0 {name=Mdumb25
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3390 -850 1 0 {name=M30
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2990 -640 3 0 {name=Mdumb5
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3090 -640 3 0 {name=Mdumb6
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3190 -640 3 0 {name=Mdumb7
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3290 -640 3 0 {name=Mdumb8
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3390 -640 3 0 {name=Mdumb9
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1890 -640 3 0 {name=Mdumb4
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1790 -640 3 0 {name=Mdumb3
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1690 -640 3 0 {name=Mdumb2
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1590 -640 3 0 {name=Mdumb1
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 3440 -1140 2 0 {name=l15 sig_type=std_logic lab=Vg}
C {madvlsi/vdd.sym} 1520 -1260 0 0 {name=l13 lab=VDD}
C {madvlsi/gnd.sym} 1540 -500 0 0 {name=l16 lab=GND}
C {madvlsi/gnd.sym} 1610 -180 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 1700 -210 0 0 {name=l3 sig_type=std_logic lab=Vbn}
C {madvlsi/vsource.sym} 1450 -1140 1 0 {name=Vg
value=1.2}
C {madvlsi/gnd.sym} 1420 -1140 1 0 {name=l4 lab=GND}
C {madvlsi/tt_models.sym} 1220 -610 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {devices/code_shown.sym} 1250 -420 0 0 {name=SPICE only_toplevel=false value=".control
tran 0.000001 10u 0.0001u
save all
plot i(viout) i(vil)
.endc"}
C {madvlsi/vsource.sym} 1610 -370 0 0 {name=Vdd
value=1.8}
C {madvlsi/gnd.sym} 1610 -340 0 0 {name=l17 lab=GND}
C {madvlsi/vdd.sym} 1610 -400 0 0 {name=l18 lab=VDD}
C {madvlsi/isource.sym} 1610 -210 2 0 {name=I1
value=0.1u}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 1830 -380 3 0 {name=X2}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 2040 -380 3 0 {name=X3}
C {madvlsi/gnd.sym} 1850 -340 0 0 {name=l39 lab=GND}
C {madvlsi/gnd.sym} 2060 -340 0 0 {name=l40 lab=GND}
C {madvlsi/vsource.sym} 1880 -260 0 0 {name=Vb0
value=1.8}
C {madvlsi/gnd.sym} 1880 -230 0 0 {name=l41 lab=GND}
C {madvlsi/vsource.sym} 2090 -260 0 0 {name=Vb1
value=1.8}
C {madvlsi/gnd.sym} 2090 -230 0 0 {name=l42 lab=GND}
C {madvlsi/vsource.sym} 2300 -260 0 0 {name=Vb2
value=1.8}
C {devices/lab_pin.sym} 1810 -300 0 0 {name=l44 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 1880 -380 2 0 {name=l45 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} 2090 -380 1 0 {name=l46 sig_type=std_logic lab=s1}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 2250 -380 3 0 {name=X5}
C {madvlsi/gnd.sym} 2270 -340 0 0 {name=l48 lab=GND}
C {madvlsi/vsource.sym} 2490 -260 0 0 {name=Vb3
value=1.8}
C {madvlsi/gnd.sym} 2300 -230 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} 2300 -380 2 0 {name=l55 sig_type=std_logic lab=s2}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 2440 -380 3 0 {name=X6}
C {madvlsi/gnd.sym} 2460 -340 0 0 {name=l62 lab=GND}
C {madvlsi/vsource.sym} 2680 -260 0 0 {name=Vb4
value=1.8}
C {madvlsi/gnd.sym} 2490 -230 0 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} 2490 -380 2 0 {name=l85 sig_type=std_logic lab=s3}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 2630 -380 3 0 {name=X7}
C {madvlsi/gnd.sym} 2650 -340 0 0 {name=l88 lab=GND}
C {madvlsi/vsource.sym} 2870 -260 0 0 {name=Vb5
value=1.8}
C {madvlsi/gnd.sym} 2680 -230 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} 2680 -380 2 0 {name=l93 sig_type=std_logic lab=s4}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 2820 -380 3 0 {name=X8}
C {madvlsi/gnd.sym} 2840 -340 0 0 {name=l96 lab=GND}
C {madvlsi/gnd.sym} 2870 -230 0 0 {name=l97 lab=GND}
C {devices/lab_pin.sym} 2870 -380 2 0 {name=l101 sig_type=std_logic lab=s5}
C {madvlsi/vsource.sym} 3060 -260 0 0 {name=Vb6
value=1.8}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 3010 -380 3 0 {name=X4}
C {madvlsi/gnd.sym} 3030 -340 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} 3060 -380 2 0 {name=l52 sig_type=std_logic lab=s6}
C {madvlsi/gnd.sym} 3060 -230 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} 1990 -500 3 0 {name=l1 sig_type=std_logic lab=b0}
C {devices/lab_pin.sym} 2290 -510 3 0 {name=l6 sig_type=std_logic lab=b2}
C {devices/lab_pin.sym} 2190 -510 3 0 {name=l7 sig_type=std_logic lab=b1}
C {devices/lab_pin.sym} 2790 -510 3 0 {name=l8 sig_type=std_logic lab=b5}
C {devices/lab_pin.sym} 2490 -510 3 0 {name=l9 sig_type=std_logic lab=b3}
C {devices/lab_pin.sym} 2590 -510 3 0 {name=l10 sig_type=std_logic lab=b4}
C {devices/lab_pin.sym} 2890 -510 3 0 {name=l11 sig_type=std_logic lab=b6}
C {devices/lab_pin.sym} 1840 -930 2 0 {name=l57 sig_type=std_logic lab=Vb0}
C {devices/lab_pin.sym} 1940 -930 2 0 {name=l5 sig_type=std_logic lab=Vb1}
C {devices/lab_pin.sym} 2340 -920 2 0 {name=l60 sig_type=std_logic lab=Vb2}
C {devices/lab_pin.sym} 2440 -920 2 0 {name=l12 sig_type=std_logic lab=Vb3}
C {devices/lab_pin.sym} 2640 -930 0 0 {name=l19 sig_type=std_logic lab=Vb4}
C {devices/lab_pin.sym} 2940 -930 0 0 {name=l20 sig_type=std_logic lab=Vb5}
C {devices/lab_pin.sym} 3040 -930 0 0 {name=l21 sig_type=std_logic lab=Vb6}
C {madvlsi/nmos3.sym} 1730 -210 0 0 {name=M1
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1730 -180 0 0 {name=l22 lab=GND}
C {madvlsi/pmos3.sym} 4800 -1060 3 0 {name=M2
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4900 -1060 3 0 {name=M2a
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 5000 -1060 3 0 {name=M3
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 5100 -1060 3 0 {name=M4a
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 5200 -1060 3 0 {name=M5a
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 5300 -1060 3 0 {name=M5b
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 5400 -1060 3 0 {name=M4b
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 5500 -1060 3 0 {name=M4
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 5600 -1060 3 0 {name=M2b
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 5700 -1060 3 0 {name=M8
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4700 -1060 3 0 {name=M1a
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 5800 -1060 3 0 {name=M1b
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4600 -1060 3 0 {name=M6
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 5900 -1060 3 0 {name=M10
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 4120 -1250 0 0 {name=l23 lab=VDD}
C {madvlsi/pmos3.sym} 6000 -1060 3 0 {name=M26
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 6100 -1060 3 0 {name=M27
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4500 -1060 3 0 {name=M50
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4400 -1060 3 0 {name=M51
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4300 -1060 3 0 {name=M52
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vsource.sym} 3950 -910 0 0 {name=Vout
value=1}
C {madvlsi/gnd.sym} 3950 -850 0 0 {name=l25 lab=GND}
C {madvlsi/ammeter1.sym} 3950 -960 0 0 {name=VIout}
C {madvlsi/nmos3.sym} 4310 -450 1 0 {name=M12
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4410 -450 1 0 {name=M14
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4510 -450 1 0 {name=Mdumb29
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4610 -450 1 0 {name=M31
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4710 -450 1 0 {name=Mdumb32
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4810 -450 1 0 {name=M33
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4910 -450 1 0 {name=Mdumb34
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5010 -450 1 0 {name=M36
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5110 -450 1 0 {name=Mdumb37
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5210 -450 1 0 {name=M39
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5310 -450 1 0 {name=Mdumb40
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5410 -450 1 0 {name=M42
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5510 -450 1 0 {name=Mdumb43
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5610 -450 1 0 {name=M45
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5710 -450 1 0 {name=M46
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4310 -220 1 0 {name=M47
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4410 -220 1 0 {name=M48
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4510 -220 1 0 {name=M49
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4610 -220 1 0 {name=M53
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4710 -220 1 0 {name=Mdumb54
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4810 -220 1 0 {name=M55
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4910 -220 1 0 {name=M56
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5010 -220 1 0 {name=M57
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5110 -220 1 0 {name=M58
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5210 -220 1 0 {name=Mdumb59
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5310 -220 1 0 {name=M60
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5410 -220 1 0 {name=M61
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5510 -220 1 0 {name=M62
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5610 -220 1 0 {name=M63
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4510 -10 3 0 {name=M64
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4610 -10 3 0 {name=Mdumb65
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4710 -10 3 0 {name=M66
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4810 -10 3 0 {name=M67
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4910 -10 3 0 {name=Mdumb68
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5010 -10 3 0 {name=M69
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5110 -10 3 0 {name=M70
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5210 -10 3 0 {name=Mdumb71
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5310 -10 3 0 {name=M72
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5410 -10 3 0 {name=M73
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5810 -450 1 0 {name=Mdumb74
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5910 -450 1 0 {name=Mdumb75
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4210 -450 1 0 {name=Mdumb76
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4110 -450 1 0 {name=Mdumb77
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4210 -220 1 0 {name=Mdumb78
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4110 -220 1 0 {name=Mdumb79
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5710 -220 1 0 {name=Mdumb80
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5810 -220 1 0 {name=Mdumb81
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5910 -220 1 0 {name=M82
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5510 -10 3 0 {name=Mdumb83
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5610 -10 3 0 {name=Mdumb84
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5710 -10 3 0 {name=Mdumb85
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5810 -10 3 0 {name=Mdumb86
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5910 -10 3 0 {name=Mdumb87
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4410 -10 3 0 {name=Mdumb88
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4310 -10 3 0 {name=Mdumb89
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4210 -10 3 0 {name=Mdumb90
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4110 -10 3 0 {name=Mdumb91
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 5960 -510 2 0 {name=l24 sig_type=std_logic lab=Vg}
C {madvlsi/vdd.sym} 4040 -630 0 0 {name=l26 lab=VDD}
C {madvlsi/gnd.sym} 4060 130 0 0 {name=l30 lab=GND}
C {madvlsi/ammeter1.sym} 3750 -1160 1 0 {name=VIl}
C {devices/lab_pin.sym} 4510 20 3 0 {name=l14 sig_type=std_logic lab=Vbn}
