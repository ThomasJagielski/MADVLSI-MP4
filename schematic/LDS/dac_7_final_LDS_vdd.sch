v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
L 4 4630 -2250 4630 -1620 {}
L 4 670 -1200 670 -1070 {}
L 4 670 -1070 840 -1070 {}
L 4 840 -1200 840 -1070 {}
L 4 670 -1200 840 -1200 {}
L 4 470 -1180 470 -1080 {}
L 4 470 -1080 650 -1080 {}
L 4 650 -1190 650 -1080 {}
L 4 470 -1190 650 -1190 {}
L 4 470 -1190 470 -1170 {}
L 4 970 -1200 970 -1070 {}
L 4 970 -1070 1140 -1070 {}
L 4 1140 -1200 1140 -1070 {}
L 4 970 -1200 1140 -1200 {}
L 4 1170 -1200 1170 -1070 {}
L 4 1170 -1070 1340 -1070 {}
L 4 1340 -1200 1340 -1070 {}
L 4 1170 -1200 1340 -1200 {}
L 4 1470 -1200 1470 -1070 {}
L 4 1470 -1070 1640 -1070 {}
L 4 1640 -1200 1640 -1070 {}
L 4 1470 -1200 1640 -1200 {}
L 4 1670 -1200 1670 -1070 {}
L 4 1670 -1070 1840 -1070 {}
L 4 1840 -1200 1840 -1070 {}
L 4 1670 -1200 1840 -1200 {}
L 4 3190 -570 3190 -440 {}
L 4 3190 -440 3360 -440 {}
L 4 3360 -570 3360 -440 {}
L 4 3190 -570 3360 -570 {}
L 4 2990 -550 2990 -450 {}
L 4 2990 -450 3170 -450 {}
L 4 3170 -560 3170 -450 {}
L 4 2990 -560 3170 -560 {}
L 4 2990 -560 2990 -540 {}
L 4 3490 -570 3490 -440 {}
L 4 3490 -440 3660 -440 {}
L 4 3660 -570 3660 -440 {}
L 4 3490 -570 3660 -570 {}
L 4 3690 -570 3690 -440 {}
L 4 3690 -440 3860 -440 {}
L 4 3860 -570 3860 -440 {}
L 4 3690 -570 3860 -570 {}
L 4 3990 -570 3990 -440 {}
L 4 3990 -440 4160 -440 {}
L 4 4160 -570 4160 -440 {}
L 4 3990 -570 4160 -570 {}
L 4 4190 -570 4190 -440 {}
L 4 4190 -440 4360 -440 {}
L 4 4360 -570 4360 -440 {}
L 4 4190 -570 4360 -570 {}
L 4 2240 -2420 2440 -2420 {}
L 4 2440 -2590 2440 -2420 {}
L 4 2240 -2590 2440 -2590 {}
L 4 2240 -2590 2240 -2420 {}
L 4 1990 -2420 2190 -2420 {}
L 4 2190 -2590 2190 -2420 {}
L 4 1990 -2590 2190 -2590 {}
L 4 1990 -2590 1990 -2420 {}
L 4 1650 -2420 1850 -2420 {}
L 4 1850 -2590 1850 -2420 {}
L 4 1650 -2590 1850 -2590 {}
L 4 1650 -2590 1650 -2420 {}
L 4 2720 -1960 2920 -1960 {}
L 4 2920 -2130 2920 -1960 {}
L 4 2720 -2130 2920 -2130 {}
L 4 2720 -2130 2720 -1960 {}
L 4 2470 -1960 2670 -1960 {}
L 4 2670 -2130 2670 -1960 {}
L 4 2470 -2130 2670 -2130 {}
L 4 2470 -2130 2470 -1960 {}
L 4 1520 -2110 1520 -1960 {}
L 4 1520 -1960 1960 -1960 {}
L 4 1960 -2110 1960 -1960 {}
L 4 1520 -2110 1960 -2110 {}
L 4 2110 -1960 2310 -1960 {}
L 4 2310 -2130 2310 -1960 {}
L 4 2110 -2130 2310 -2130 {}
L 4 2110 -2130 2110 -1960 {}
L 4 2600 -2420 2800 -2420 {}
L 4 2800 -2590 2800 -2420 {}
L 4 2600 -2590 2800 -2590 {}
L 4 2600 -2590 2600 -2420 {}
L 4 2240 -2180 2440 -2180 {}
L 4 2440 -2350 2440 -2180 {}
L 4 2240 -2350 2440 -2350 {}
L 4 2240 -2350 2240 -2180 {}
L 4 1990 -2180 2190 -2180 {}
L 4 2190 -2350 2190 -2180 {}
L 4 1990 -2350 2190 -2350 {}
L 4 1990 -2350 1990 -2180 {}
L 4 1650 -2180 1850 -2180 {}
L 4 1850 -2350 1850 -2180 {}
L 4 1650 -2350 1850 -2350 {}
L 4 1650 -2350 1650 -2180 {}
L 4 2600 -2180 2800 -2180 {}
L 4 2800 -2350 2800 -2180 {}
L 4 2600 -2350 2800 -2350 {}
L 4 2600 -2350 2600 -2180 {}
L 4 2720 -1710 2920 -1710 {}
L 4 2920 -1880 2920 -1710 {}
L 4 2720 -1880 2920 -1880 {}
L 4 2720 -1880 2720 -1710 {}
L 4 2470 -1710 2670 -1710 {}
L 4 2670 -1880 2670 -1710 {}
L 4 2470 -1880 2670 -1880 {}
L 4 2470 -1880 2470 -1710 {}
L 4 1520 -1860 1520 -1710 {}
L 4 1520 -1710 1960 -1710 {}
L 4 1960 -1860 1960 -1710 {}
L 4 1520 -1860 1960 -1860 {}
L 4 2110 -1710 2310 -1710 {}
L 4 2310 -1880 2310 -1710 {}
L 4 2110 -1880 2310 -1880 {}
L 4 2110 -1880 2110 -1710 {}
T {M34} 2320 -2570 0 0 0.4 0.4 {}
T {M31} 2070 -2570 0 0 0.4 0.4 {}
T {M30} 1730 -2570 0 0 0.4 0.4 {}
T {M55} 1720 -2070 0 0 0.4 0.4 {}
T {M56} 2190 -2070 0 0 0.4 0.4 {}
T {M35} 2680 -2570 0 0 0.4 0.4 {}
T {M57} 2550 -2070 0 0 0.4 0.4 {}
T {M61} 2800 -2070 0 0 0.4 0.4 {}
T {M34} 2320 -2330 0 0 0.4 0.4 {}
T {M31} 2070 -2330 0 0 0.4 0.4 {}
T {M30} 1730 -2330 0 0 0.4 0.4 {}
T {M35} 2680 -2330 0 0 0.4 0.4 {}
T {M55} 1720 -1820 0 0 0.4 0.4 {}
T {M56} 2190 -1820 0 0 0.4 0.4 {}
T {M57} 2550 -1820 0 0 0.4 0.4 {}
T {M61} 2800 -1820 0 0 0.4 0.4 {}
N 3890 -1860 3890 -1690 { lab=Vbn}
N 3790 -1860 3790 -1690 { lab=Vbn}
N 3790 -1690 3890 -1690 { lab=Vbn}
N 4160 -1950 4480 -1950 { lab=Vg}
N 3890 -1690 4480 -1690 { lab=Vbn}
N 4090 -1830 4630 -1830 { lab=#net10}
N 4780 -1950 5000 -1950 { lab=Vg}
N 3520 -1690 3790 -1690 { lab=Vbn}
N 1220 -1950 1270 -1950 { lab=#net11}
N 4680 -1950 4780 -1950 { lab=Vg}
N 4880 -1860 4910 -1860 { lab=GND}
N 4910 -1890 4910 -1860 { lab=GND}
N 4880 -1750 4910 -1750 { lab=GND}
N 4910 -1780 4910 -1750 { lab=GND}
N 4880 -2090 4910 -2090 { lab=GND}
N 4910 -2120 4910 -2090 { lab=GND}
N 4880 -1980 4910 -1980 { lab=GND}
N 4910 -2010 4910 -1980 { lab=GND}
N 4350 -1890 4350 -1860 { lab=GND}
N 4350 -1860 4380 -1860 { lab=GND}
N 4350 -1780 4350 -1750 { lab=GND}
N 4350 -1750 4380 -1750 { lab=GND}
N 4350 -2120 4350 -2090 { lab=GND}
N 4350 -2090 4380 -2090 { lab=GND}
N 4350 -2010 4350 -1980 { lab=GND}
N 4350 -1980 4380 -1980 { lab=GND}
N 4430 -2010 4450 -2010 { lab=VDD}
N 4430 -1890 4450 -1890 { lab=VDD}
N 4430 -2120 4450 -2120 { lab=VDD}
N 4430 -1780 4450 -1780 { lab=GND}
N 4530 -2010 4550 -2010 { lab=#net12}
N 4530 -2120 4550 -2120 { lab=#net13}
N 4530 -1780 4550 -1780 { lab=#net14}
N 4630 -2010 4650 -2010 { lab=#net10}
N 4630 -2120 4650 -2120 { lab=#net10}
N 4830 -2010 4850 -2010 { lab=VDD}
N 4830 -1890 4850 -1890 { lab=VDD}
N 4830 -2120 4850 -2120 { lab=VDD}
N 4830 -1780 4850 -1780 { lab=GND}
N 4430 -2150 4430 -2120 { lab=VDD}
N 4410 -2120 4430 -2120 { lab=VDD}
N 4430 -2120 4430 -2010 { lab=VDD}
N 4410 -2010 4430 -2010 { lab=VDD}
N 4430 -2010 4430 -1890 { lab=VDD}
N 4410 -1890 4430 -1890 { lab=VDD}
N 4410 -1780 4430 -1780 { lab=GND}
N 4730 -2010 4750 -2010 { lab=#net12}
N 4730 -2120 4750 -2120 { lab=#net13}
N 4730 -1780 4750 -1780 { lab=#net14}
N 4830 -2150 4830 -2120 { lab=VDD}
N 4830 -2120 4830 -2010 { lab=VDD}
N 4830 -2010 4830 -1890 { lab=VDD}
N 4810 -2120 4830 -2120 { lab=VDD}
N 4810 -2010 4830 -2010 { lab=VDD}
N 4810 -1890 4830 -1890 { lab=VDD}
N 4810 -1780 4830 -1780 { lab=GND}
N 4530 -1890 4550 -1890 { lab=#net15}
N 4630 -1890 4650 -1890 { lab=#net10}
N 4730 -1890 4750 -1890 { lab=#net15}
N 4480 -1950 4480 -1920 { lab=Vg}
N 4480 -2090 4480 -1950 { lab=Vg}
N 4580 -1950 4580 -1920 { lab=Vg}
N 4480 -1950 4580 -1950 { lab=Vg}
N 4580 -2090 4580 -1950 { lab=Vg}
N 4680 -1950 4680 -1920 { lab=Vg}
N 4680 -2090 4680 -1950 { lab=Vg}
N 4580 -1950 4680 -1950 { lab=Vg}
N 4780 -1950 4780 -1920 { lab=Vg}
N 4630 -2120 4630 -2010 { lab=#net10}
N 4610 -2120 4630 -2120 { lab=#net10}
N 4610 -2010 4630 -2010 { lab=#net10}
N 4630 -2010 4630 -1890 { lab=#net10}
N 4610 -1890 4630 -1890 { lab=#net10}
N 4530 -1810 4530 -1780 { lab=#net14}
N 4510 -1780 4530 -1780 { lab=#net14}
N 4530 -1810 4730 -1810 { lab=#net14}
N 4730 -1810 4730 -1780 { lab=#net14}
N 4710 -1780 4730 -1780 { lab=#net14}
N 4530 -1890 4530 -1860 { lab=#net15}
N 4510 -1890 4530 -1890 { lab=#net15}
N 4530 -1860 4730 -1860 { lab=#net15}
N 4730 -1890 4730 -1860 { lab=#net15}
N 4710 -1890 4730 -1890 { lab=#net15}
N 4730 -2040 4730 -2010 { lab=#net12}
N 4710 -2010 4730 -2010 { lab=#net12}
N 4530 -2040 4730 -2040 { lab=#net12}
N 4530 -2040 4530 -2010 { lab=#net12}
N 4510 -2010 4530 -2010 { lab=#net12}
N 4530 -2150 4530 -2120 { lab=#net13}
N 4510 -2120 4530 -2120 { lab=#net13}
N 4530 -2150 4730 -2150 { lab=#net13}
N 4730 -2150 4730 -2120 { lab=#net13}
N 4710 -2120 4730 -2120 { lab=#net13}
N 4780 -1750 4780 -1690 { lab=Vbn}
N 4680 -1750 4680 -1690 { lab=Vbn}
N 4580 -1750 4580 -1690 { lab=Vbn}
N 4480 -1750 4480 -1690 { lab=Vbn}
N 4680 -1690 4780 -1690 { lab=Vbn}
N 4580 -1690 4680 -1690 { lab=Vbn}
N 4480 -1690 4580 -1690 { lab=Vbn}
N 4630 -1830 4630 -1780 { lab=#net10}
N 4780 -2090 4780 -1950 { lab=Vg}
N 4630 -1890 4630 -1830 { lab=#net10}
N 4610 -1780 4630 -1780 { lab=#net10}
N 4630 -1780 4650 -1780 { lab=#net10}
N 3820 -2010 3860 -2010 { lab=#net16}
N 3820 -1890 3860 -1890 { lab=#net17}
N 3940 -1890 3960 -1890 { lab=GND}
N 3940 -2010 3960 -2010 { lab=VDD}
N 4020 -2010 4060 -2010 { lab=#net18}
N 4020 -1890 4060 -1890 { lab=#net19}
N 4120 -1890 4160 -1890 { lab=Vg}
N 4120 -2010 4160 -2010 { lab=Vg}
N 4020 -1780 4060 -1780 { lab=#net19}
N 3720 -1780 3760 -1780 { lab=#net20}
N 3820 -1780 3860 -1780 { lab=#net17}
N 3940 -1780 3960 -1780 { lab=GND}
N 3720 -2010 3760 -2010 { lab=#net20}
N 3720 -1890 3760 -1890 { lab=#net20}
N 4120 -1780 4160 -1780 { lab=Vg}
N 3940 -1890 3940 -1780 { lab=GND}
N 3940 -1780 3940 -1730 { lab=GND}
N 3890 -2070 3890 -2040 { lab=#net20}
N 3790 -2070 3790 -2040 { lab=#net20}
N 3990 -2070 3990 -2040 { lab=#net20}
N 4090 -2070 4090 -2040 { lab=#net20}
N 3720 -1890 3720 -1780 { lab=#net20}
N 4160 -1890 4160 -1780 { lab=Vg}
N 3820 -2120 3860 -2120 { lab=#net16}
N 3940 -2120 3960 -2120 { lab=VDD}
N 4020 -2120 4060 -2120 { lab=#net18}
N 4120 -2120 4160 -2120 { lab=Vg}
N 3720 -2120 3760 -2120 { lab=#net20}
N 3720 -2070 3720 -2010 { lab=#net20}
N 4160 -2120 4160 -2010 { lab=Vg}
N 3940 -2120 3940 -2010 { lab=VDD}
N 3940 -2150 3940 -2120 { lab=VDD}
N 3720 -2010 3720 -1890 { lab=#net20}
N 4160 -1950 4160 -1890 { lab=Vg}
N 3790 -2070 3890 -2070 { lab=#net20}
N 3660 -2040 3690 -2040 { lab=VDD}
N 3660 -2040 3660 -2010 { lab=VDD}
N 3660 -2150 3690 -2150 { lab=VDD}
N 3660 -2150 3660 -2120 { lab=VDD}
N 3660 -1890 3660 -1860 { lab=GND}
N 3660 -1860 3690 -1860 { lab=GND}
N 3660 -1780 3660 -1750 { lab=GND}
N 3660 -1750 3690 -1750 { lab=GND}
N 4190 -1860 4220 -1860 { lab=GND}
N 4220 -1890 4220 -1860 { lab=GND}
N 4190 -1750 4220 -1750 { lab=GND}
N 4220 -1780 4220 -1750 { lab=GND}
N 4190 -2040 4220 -2040 { lab=VDD}
N 4220 -2040 4220 -2010 { lab=VDD}
N 4190 -2150 4220 -2150 { lab=VDD}
N 4220 -2150 4220 -2120 { lab=VDD}
N 3890 -2070 3990 -2070 { lab=#net20}
N 3990 -2070 4090 -2070 { lab=#net20}
N 3720 -2070 3790 -2070 { lab=#net20}
N 3920 -1890 3940 -1890 { lab=GND}
N 3920 -1780 3940 -1780 { lab=GND}
N 3920 -2120 3940 -2120 { lab=VDD}
N 3920 -2010 3940 -2010 { lab=VDD}
N 3790 -2090 3790 -2070 { lab=#net20}
N 3890 -2090 3890 -2070 { lab=#net20}
N 3990 -2090 3990 -2070 { lab=#net20}
N 4090 -2090 4090 -2070 { lab=#net20}
N 3720 -2120 3720 -2070 { lab=#net20}
N 4160 -2010 4160 -1950 { lab=Vg}
N 3990 -1830 3990 -1810 { lab=#net10}
N 4090 -1830 4090 -1810 { lab=#net10}
N 3990 -1830 4090 -1830 { lab=#net10}
N 3990 -1860 3990 -1830 { lab=#net10}
N 4090 -1860 4090 -1830 { lab=#net10}
N 3840 -2120 3840 -2010 { lab=#net16}
N 4040 -2120 4040 -2010 { lab=#net18}
N 3840 -1890 3840 -1780 { lab=#net17}
N 4040 -1890 4040 -1780 { lab=#net19}
N 540 -1360 580 -1360 { lab=VDD}
N 640 -1360 680 -1360 { lab=#net21}
N 740 -1360 780 -1360 { lab=#net22}
N 840 -1360 880 -1360 { lab=VDD}
N 940 -1360 980 -1360 { lab=VDD}
N 1040 -1360 1080 -1360 { lab=#net23}
N 1140 -1360 1180 -1360 { lab=#net24}
N 1240 -1360 1280 -1360 { lab=VDD}
N 1340 -1360 1380 -1360 { lab=#net25}
N 1440 -1360 1480 -1360 { lab=VDD}
N 1540 -1360 1580 -1360 { lab=#net26}
N 1640 -1360 1680 -1360 { lab=VDD}
N 1740 -1360 1780 -1360 { lab=#net27}
N 1840 -1360 1880 -1360 { lab=#net28}
N 540 -1130 580 -1130 { lab=#net21}
N 640 -1130 680 -1130 { lab=#net22}
N 740 -1130 780 -1130 { lab=#net23}
N 840 -1130 880 -1130 { lab=#net22}
N 940 -1130 980 -1130 { lab=#net24}
N 1040 -1130 1080 -1130 { lab=#net23}
N 1140 -1130 1180 -1130 { lab=#net24}
N 1240 -1130 1280 -1130 { lab=#net25}
N 1340 -1130 1380 -1130 { lab=#net24}
N 1440 -1130 1480 -1130 { lab=#net26}
N 1540 -1130 1580 -1130 { lab=#net25}
N 1640 -1130 1680 -1130 { lab=#net26}
N 1740 -1130 1780 -1130 { lab=#net27}
N 740 -920 780 -920 { lab=#net21}
N 840 -920 880 -920 { lab=#net22}
N 940 -920 980 -920 { lab=GND}
N 1040 -920 1080 -920 { lab=#net23}
N 1140 -920 1180 -920 { lab=#net24}
N 1240 -920 1280 -920 { lab=GND}
N 1340 -920 1380 -920 { lab=#net25}
N 1440 -920 1480 -920 { lab=#net26}
N 1540 -920 1580 -920 { lab=GND}
N 340 -820 2200 -820 { lab=GND}
N 660 -920 660 -820 { lab=GND}
N 710 -890 710 -780 { lab=b0}
N 910 -890 910 -790 { lab=b1}
N 1010 -890 1010 -790 { lab=b2}
N 1210 -890 1210 -790 { lab=b3}
N 1310 -890 1310 -790 { lab=b4}
N 1510 -890 1510 -790 { lab=b5}
N 1610 -890 1610 -790 { lab=b6}
N 300 -1420 2160 -1420 { lab=Vg}
N 810 -890 810 -820 { lab=GND}
N 1110 -890 1110 -820 { lab=GND}
N 1410 -890 1410 -820 { lab=GND}
N 1560 -920 1560 -820 { lab=GND}
N 960 -920 960 -820 { lab=GND}
N 1260 -920 1260 -820 { lab=GND}
N 510 -1420 510 -1390 { lab=Vg}
N 610 -1420 610 -1390 { lab=Vg}
N 810 -1420 810 -1390 { lab=Vg}
N 1010 -1420 1010 -1390 { lab=Vg}
N 1210 -1420 1210 -1390 { lab=Vg}
N 1410 -1420 1410 -1390 { lab=Vg}
N 1610 -1420 1610 -1390 { lab=Vg}
N 1810 -1420 1810 -1390 { lab=Vg}
N 1910 -1420 1910 -1390 { lab=Vg}
N 460 -1360 460 -1300 { lab=#net21}
N 460 -1300 660 -1300 { lab=#net21}
N 660 -1360 660 -1300 { lab=#net21}
N 1760 -1360 1760 -1300 { lab=#net27}
N 1760 -1300 1960 -1300 { lab=#net27}
N 1960 -1360 1960 -1300 { lab=#net27}
N 710 -1390 710 -1280 { lab=GND}
N 910 -1390 910 -1280 { lab=GND}
N 1110 -1390 1110 -1280 { lab=GND}
N 1310 -1390 1310 -1280 { lab=GND}
N 1510 -1390 1510 -1280 { lab=GND}
N 1710 -1390 1710 -1280 { lab=GND}
N 280 -1280 1710 -1280 { lab=GND}
N 280 -820 340 -820 { lab=GND}
N 460 -1130 460 -1060 { lab=#net22}
N 460 -1060 860 -1060 { lab=#net22}
N 860 -1130 860 -1060 { lab=#net22}
N 1460 -1130 1460 -1060 { lab=#net26}
N 1460 -1060 1860 -1060 { lab=#net26}
N 1860 -1130 1860 -1060 { lab=#net26}
N 960 -1130 960 -1060 { lab=#net24}
N 960 -1060 1360 -1060 { lab=#net24}
N 1360 -1130 1360 -1060 { lab=#net24}
N 910 -1280 910 -1160 { lab=GND}
N 1410 -1280 1410 -1160 { lab=GND}
N 510 -1170 510 -1160 { lab=Vg}
N 510 -1170 1810 -1170 { lab=Vg}
N 1810 -1170 1810 -1160 { lab=Vg}
N 1710 -1170 1710 -1160 { lab=Vg}
N 1610 -1170 1610 -1160 { lab=Vg}
N 1510 -1170 1510 -1160 { lab=Vg}
N 1310 -1170 1310 -1160 { lab=Vg}
N 1210 -1170 1210 -1160 { lab=Vg}
N 1110 -1170 1110 -1160 { lab=Vg}
N 1010 -1170 1010 -1160 { lab=Vg}
N 810 -1170 810 -1160 { lab=Vg}
N 710 -1170 710 -1160 { lab=Vg}
N 610 -1170 610 -1160 { lab=Vg}
N 560 -1520 560 -1360 { lab=VDD}
N 300 -1170 510 -1170 { lab=Vg}
N 560 -1300 560 -1130 { lab=#net21}
N 560 -1130 560 -990 { lab=#net21}
N 560 -990 760 -990 { lab=#net21}
N 760 -990 760 -920 { lab=#net21}
N 660 -1130 660 -1060 { lab=#net22}
N 660 -1250 660 -1130 { lab=#net22}
N 660 -1250 760 -1250 { lab=#net22}
N 760 -1360 760 -1250 { lab=#net22}
N 860 -1520 860 -1360 { lab=VDD}
N 660 -1060 660 -1010 { lab=#net22}
N 660 -1010 860 -1010 { lab=#net22}
N 860 -1010 860 -920 { lab=#net22}
N 960 -1520 960 -1360 { lab=VDD}
N 1860 -1440 1860 -1360 { lab=#net28}
N 1860 -1440 2160 -1440 { lab=#net28}
N 1060 -1360 1060 -1230 { lab=#net23}
N 760 -1230 1060 -1230 { lab=#net23}
N 760 -1230 760 -1130 { lab=#net23}
N 1060 -1230 1060 -1130 { lab=#net23}
N 1260 -1520 1260 -1360 { lab=VDD}
N 1060 -1130 1060 -920 { lab=#net23}
N 1760 -1130 1760 -1000 { lab=#net27}
N 1760 -1300 1760 -1130 { lab=#net27}
N 1560 -1360 1560 -1250 { lab=#net26}
N 1560 -1250 1660 -1250 { lab=#net26}
N 1660 -1250 1660 -1130 { lab=#net26}
N 1660 -1130 1660 -1060 { lab=#net26}
N 1460 -1060 1460 -920 { lab=#net26}
N 1360 -1210 1560 -1210 { lab=#net25}
N 1560 -1210 1560 -1130 { lab=#net25}
N 1560 -1130 1560 -1020 { lab=#net25}
N 1360 -1020 1560 -1020 { lab=#net25}
N 1360 -1020 1360 -920 { lab=#net25}
N 1160 -1360 1160 -1130 { lab=#net24}
N 1160 -1130 1160 -1060 { lab=#net24}
N 1160 -1060 1160 -920 { lab=#net24}
N 1260 -1130 1260 -1020 { lab=#net25}
N 1260 -1020 1360 -1020 { lab=#net25}
N 240 -1420 300 -1420 { lab=Vg}
N 240 -1420 240 -1170 { lab=Vg}
N 240 -1170 300 -1170 { lab=Vg}
N 260 -1280 280 -1280 { lab=GND}
N 260 -1280 260 -820 { lab=GND}
N 260 -820 280 -820 { lab=GND}
N 1360 -1360 1360 -1210 { lab=#net25}
N 310 -1390 410 -1390 { lab=GND}
N 340 -1360 380 -1360 { lab=GND}
N 280 -1390 280 -1360 { lab=GND}
N 280 -1390 310 -1390 { lab=GND}
N 360 -1390 360 -1360 { lab=GND}
N 440 -1360 480 -1360 { lab=#net21}
N 360 -1360 360 -1280 { lab=GND}
N 1940 -1360 1980 -1360 { lab=#net27}
N 2010 -1390 2110 -1390 { lab=GND}
N 2110 -1390 2140 -1390 { lab=GND}
N 2140 -1390 2140 -1360 { lab=GND}
N 2040 -1360 2080 -1360 { lab=GND}
N 2060 -1390 2060 -1360 { lab=GND}
N 1710 -1280 2060 -1280 { lab=GND}
N 2060 -1360 2060 -1280 { lab=GND}
N 440 -1130 480 -1130 { lab=#net22}
N 310 -1160 410 -1160 { lab=GND}
N 280 -1160 310 -1160 { lab=GND}
N 280 -1160 280 -1130 { lab=GND}
N 340 -1130 380 -1130 { lab=GND}
N 360 -1160 360 -1130 { lab=GND}
N 260 -1130 280 -1130 { lab=GND}
N 340 -920 380 -920 { lab=GND}
N 440 -920 480 -920 { lab=GND}
N 540 -920 580 -920 { lab=GND}
N 640 -920 680 -920 { lab=GND}
N 280 -890 610 -890 { lab=GND}
N 280 -920 280 -890 { lab=GND}
N 360 -920 360 -890 { lab=GND}
N 460 -920 460 -890 { lab=GND}
N 560 -920 560 -890 { lab=GND}
N 460 -890 460 -820 { lab=GND}
N 1660 -1000 1660 -920 { lab=#net27}
N 1660 -1000 1760 -1000 { lab=#net27}
N 1640 -920 1680 -920 { lab=#net27}
N 1710 -890 2140 -890 { lab=GND}
N 2140 -920 2140 -890 { lab=GND}
N 2040 -920 2080 -920 { lab=GND}
N 1940 -920 1980 -920 { lab=GND}
N 1840 -920 1880 -920 { lab=GND}
N 1740 -920 1780 -920 { lab=GND}
N 1760 -920 1760 -890 { lab=GND}
N 1860 -920 1860 -890 { lab=GND}
N 1960 -920 1960 -890 { lab=GND}
N 2060 -920 2060 -890 { lab=GND}
N 1910 -890 1910 -820 { lab=GND}
N 1840 -1130 1880 -1130 { lab=#net26}
N 1940 -1130 1980 -1130 { lab=GND}
N 2040 -1130 2080 -1130 { lab=GND}
N 1910 -1160 2140 -1160 { lab=GND}
N 2140 -1160 2140 -1130 { lab=GND}
N 2060 -1160 2060 -1130 { lab=GND}
N 1960 -1160 1960 -1130 { lab=GND}
N 2060 -1280 2060 -1160 { lab=GND}
N 240 -1520 2200 -1520 { lab=VDD}
N 240 -1540 240 -1520 { lab=VDD}
N 260 -820 260 -780 { lab=GND}
N 1660 -1520 1660 -1360 { lab=VDD}
N 1460 -1520 1460 -1360 { lab=VDD}
N 1610 -790 1730 -790 { lab=b6}
N 1730 -790 1730 -700 { lab=b6}
N 1540 -790 1540 -700 { lab=b5}
N 1350 -790 1350 -700 { lab=b4}
N 1160 -790 1160 -700 { lab=b3}
N 970 -790 970 -700 { lab=b2}
N 760 -790 760 -700 { lab=b1}
N 550 -780 550 -700 { lab=b0}
N 550 -780 710 -780 { lab=b0}
N 200 -1420 240 -1420 { lab=Vg}
N 2170 -1440 2190 -1440 { lab=#net28}
N 2160 -1440 2170 -1440 { lab=#net28}
N 800 -660 810 -660 { lab=s1}
N 810 -660 810 -570 { lab=s1}
N 590 -660 600 -660 { lab=s0}
N 600 -660 600 -570 { lab=s0}
N 640 -580 740 -580 { lab=Vbn}
N 740 -580 840 -580 { lab=Vbn}
N 530 -620 530 -580 { lab=Vbn}
N 740 -620 740 -580 { lab=Vbn}
N 1010 -660 1020 -660 { lab=s2}
N 1020 -660 1020 -570 { lab=s2}
N 950 -580 1140 -580 { lab=Vbn}
N 950 -620 950 -580 { lab=Vbn}
N 1200 -660 1210 -660 { lab=s3}
N 1210 -660 1210 -570 { lab=s3}
N 1140 -580 1330 -580 { lab=Vbn}
N 1140 -620 1140 -580 { lab=Vbn}
N 1390 -660 1400 -660 { lab=s4}
N 1400 -660 1400 -570 { lab=s4}
N 1330 -580 1520 -580 { lab=Vbn}
N 1330 -620 1330 -580 { lab=Vbn}
N 1580 -660 1590 -660 { lab=s5}
N 1590 -660 1590 -570 { lab=s5}
N 1520 -580 1710 -580 { lab=Vbn}
N 1520 -620 1520 -580 { lab=Vbn}
N 840 -580 950 -580 { lab=Vbn}
N 1710 -620 1710 -580 { lab=Vbn}
N 1770 -660 1780 -660 { lab=s6}
N 1780 -660 1780 -570 { lab=s6}
N 530 -580 640 -580 { lab=Vbn}
N 1510 -790 1540 -790 { lab=b5}
N 1310 -790 1350 -790 { lab=b4}
N 1160 -790 1210 -790 { lab=b3}
N 970 -790 1010 -790 { lab=b2}
N 760 -790 910 -790 { lab=b1}
N 3720 -1310 3720 -1290 { lab=#net29}
N 3720 -1290 3920 -1290 { lab=#net29}
N 3920 -1310 3920 -1290 { lab=#net29}
N 3820 -1310 3820 -1290 { lab=#net29}
N 3650 -1340 3690 -1340 { lab=#net30}
N 3750 -1340 3790 -1340 { lab=VDD}
N 3850 -1340 3890 -1340 { lab=#net31}
N 3570 -1340 3570 -1290 { lab=#net32}
N 3570 -1290 3570 -1220 { lab=#net32}
N 3670 -1340 3670 -1180 { lab=#net30}
N 3920 -1290 3970 -1290 { lab=#net29}
N 3970 -1340 3990 -1340 { lab=#net29}
N 3970 -1290 4220 -1290 { lab=#net29}
N 4220 -1310 4220 -1290 { lab=#net29}
N 4120 -1310 4120 -1290 { lab=#net29}
N 4020 -1310 4020 -1290 { lab=#net29}
N 4050 -1340 4090 -1340 { lab=#net31}
N 4150 -1340 4190 -1340 { lab=VDD}
N 4250 -1340 4290 -1340 { lab=#net30}
N 4370 -1340 4370 -1290 { lab=#net32}
N 4370 -1290 4370 -1220 { lab=#net32}
N 4270 -1340 4270 -1180 { lab=#net30}
N 3950 -1340 3970 -1340 { lab=#net29}
N 3520 -1530 3520 -1310 { lab=VDD}
N 4420 -1530 4420 -1310 { lab=VDD}
N 3350 -1340 3390 -1340 { lab=Vout}
N 3370 -1340 3370 -1260 { lab=Vout}
N 3450 -1340 3490 -1340 { lab=#net31}
N 3550 -1340 3590 -1340 { lab=#net32}
N 3420 -1310 3420 -1290 { lab=#net32}
N 3420 -1290 3590 -1290 { lab=#net32}
N 3590 -1290 3620 -1290 { lab=#net32}
N 3620 -1310 3620 -1290 { lab=#net32}
N 4350 -1340 4390 -1340 { lab=#net32}
N 4450 -1340 4490 -1340 { lab=#net31}
N 4320 -1310 4320 -1290 { lab=#net32}
N 4320 -1290 4370 -1290 { lab=#net32}
N 4370 -1290 4520 -1290 { lab=#net32}
N 4520 -1310 4520 -1290 { lab=#net32}
N 4550 -1340 4590 -1340 { lab=Vout}
N 4570 -1340 4570 -1260 { lab=Vout}
N 3470 -1440 3470 -1340 { lab=#net31}
N 3470 -1440 4470 -1440 { lab=#net31}
N 4470 -1440 4470 -1340 { lab=#net31}
N 4070 -1440 4070 -1340 { lab=#net31}
N 3870 -1440 3870 -1340 { lab=#net31}
N 3770 -1530 3770 -1340 { lab=VDD}
N 4170 -1530 4170 -1340 { lab=VDD}
N 3570 -1220 3570 -1150 { lab=#net32}
N 4370 -1220 4370 -1150 { lab=#net32}
N 3570 -1150 4370 -1150 { lab=#net32}
N 3250 -1340 3290 -1340 { lab=VDD}
N 3320 -1310 3320 -1290 { lab=VDD}
N 3270 -1340 3270 -1290 { lab=VDD}
N 3270 -1530 3270 -1340 { lab=VDD}
N 4620 -1310 4620 -1290 { lab=VDD}
N 4620 -1290 4670 -1290 { lab=VDD}
N 4670 -1340 4670 -1290 { lab=VDD}
N 4650 -1340 4690 -1340 { lab=VDD}
N 4670 -1530 4670 -1340 { lab=VDD}
N 2840 -1530 5020 -1530 { lab=VDD}
N 2970 -1340 2990 -1340 { lab=VDD}
N 2970 -1340 2970 -1290 { lab=VDD}
N 2970 -1290 3320 -1290 { lab=VDD}
N 3050 -1340 3090 -1340 { lab=VDD}
N 3150 -1340 3190 -1340 { lab=VDD}
N 3170 -1340 3170 -1290 { lab=VDD}
N 3070 -1340 3070 -1290 { lab=VDD}
N 3120 -1310 3120 -1290 { lab=VDD}
N 3020 -1310 3020 -1290 { lab=VDD}
N 3220 -1310 3220 -1290 { lab=VDD}
N 4720 -1310 4720 -1290 { lab=VDD}
N 4720 -1290 4870 -1290 { lab=VDD}
N 4870 -1340 4870 -1290 { lab=VDD}
N 4850 -1340 4870 -1340 { lab=VDD}
N 4820 -1310 4820 -1290 { lab=VDD}
N 4750 -1340 4790 -1340 { lab=VDD}
N 4770 -1340 4770 -1290 { lab=VDD}
N 4670 -1290 4720 -1290 { lab=VDD}
N 3970 -1340 3970 -1090 { lab=#net29}
N 2670 -1260 2670 -1250 { lab=Vout}
N 2670 -1160 2670 -1140 { lab=GND}
N 2670 -1140 2670 -1130 { lab=GND}
N 2670 -1250 2670 -1240 { lab=Vout}
N 2670 -1230 2670 -1220 { lab=#net33}
N 3060 -730 3100 -730 { lab=VDD}
N 3160 -730 3200 -730 { lab=#net34}
N 3260 -730 3300 -730 { lab=#net35}
N 3360 -730 3400 -730 { lab=VDD}
N 3460 -730 3500 -730 { lab=VDD}
N 3560 -730 3600 -730 { lab=#net36}
N 3660 -730 3700 -730 { lab=#net37}
N 3760 -730 3800 -730 { lab=VDD}
N 3860 -730 3900 -730 { lab=#net38}
N 3960 -730 4000 -730 { lab=VDD}
N 4060 -730 4100 -730 { lab=#net39}
N 4160 -730 4200 -730 { lab=#net29}
N 4260 -730 4300 -730 { lab=#net40}
N 4360 -730 4400 -730 { lab=#net32}
N 3060 -500 3100 -500 { lab=#net34}
N 3160 -500 3200 -500 { lab=#net35}
N 3260 -500 3300 -500 { lab=#net36}
N 3360 -500 3400 -500 { lab=#net35}
N 3460 -500 3500 -500 { lab=#net37}
N 3560 -500 3600 -500 { lab=#net36}
N 3660 -500 3700 -500 { lab=#net37}
N 3760 -500 3800 -500 { lab=#net38}
N 3860 -500 3900 -500 { lab=#net37}
N 3960 -500 4000 -500 { lab=#net39}
N 4060 -500 4100 -500 { lab=#net38}
N 4160 -500 4200 -500 { lab=#net39}
N 4260 -500 4300 -500 { lab=#net40}
N 3260 -290 3300 -290 { lab=#net34}
N 3360 -290 3400 -290 { lab=#net35}
N 3460 -290 3500 -290 { lab=GND}
N 3560 -290 3600 -290 { lab=#net36}
N 3660 -290 3700 -290 { lab=#net37}
N 3760 -290 3800 -290 { lab=GND}
N 3860 -290 3900 -290 { lab=#net38}
N 3960 -290 4000 -290 { lab=#net39}
N 4060 -290 4100 -290 { lab=GND}
N 2860 -190 4720 -190 { lab=GND}
N 3180 -290 3180 -190 { lab=GND}
N 2820 -790 4680 -790 { lab=Vg}
N 3330 -260 3330 -190 { lab=GND}
N 3630 -260 3630 -190 { lab=GND}
N 3930 -260 3930 -190 { lab=GND}
N 4080 -290 4080 -190 { lab=GND}
N 3480 -290 3480 -190 { lab=GND}
N 3780 -290 3780 -190 { lab=GND}
N 3030 -790 3030 -760 { lab=Vg}
N 3130 -790 3130 -760 { lab=Vg}
N 3330 -790 3330 -760 { lab=Vg}
N 3530 -790 3530 -760 { lab=Vg}
N 3730 -790 3730 -760 { lab=Vg}
N 3930 -790 3930 -760 { lab=Vg}
N 4130 -790 4130 -760 { lab=Vg}
N 4330 -790 4330 -760 { lab=Vg}
N 4430 -790 4430 -760 { lab=Vg}
N 2980 -730 2980 -670 { lab=#net34}
N 2980 -670 3180 -670 { lab=#net34}
N 3180 -730 3180 -670 { lab=#net34}
N 4280 -730 4280 -670 { lab=#net40}
N 4280 -670 4480 -670 { lab=#net40}
N 4480 -730 4480 -670 { lab=#net40}
N 3230 -760 3230 -650 { lab=GND}
N 3430 -760 3430 -650 { lab=GND}
N 3630 -760 3630 -650 { lab=GND}
N 3830 -760 3830 -650 { lab=GND}
N 4030 -760 4030 -650 { lab=GND}
N 4230 -760 4230 -650 { lab=GND}
N 2800 -650 4230 -650 { lab=GND}
N 2800 -190 2860 -190 { lab=GND}
N 2980 -500 2980 -430 { lab=#net35}
N 2980 -430 3380 -430 { lab=#net35}
N 3380 -500 3380 -430 { lab=#net35}
N 3980 -500 3980 -430 { lab=#net39}
N 3980 -430 4380 -430 { lab=#net39}
N 4380 -500 4380 -430 { lab=#net39}
N 3480 -500 3480 -430 { lab=#net37}
N 3480 -430 3880 -430 { lab=#net37}
N 3880 -500 3880 -430 { lab=#net37}
N 3430 -650 3430 -530 { lab=GND}
N 3930 -650 3930 -530 { lab=GND}
N 3030 -540 3030 -530 { lab=Vg}
N 3030 -540 4330 -540 { lab=Vg}
N 4330 -540 4330 -530 { lab=Vg}
N 4230 -540 4230 -530 { lab=Vg}
N 4130 -540 4130 -530 { lab=Vg}
N 4030 -540 4030 -530 { lab=Vg}
N 3830 -540 3830 -530 { lab=Vg}
N 3730 -540 3730 -530 { lab=Vg}
N 3630 -540 3630 -530 { lab=Vg}
N 3530 -540 3530 -530 { lab=Vg}
N 3330 -540 3330 -530 { lab=Vg}
N 3230 -540 3230 -530 { lab=Vg}
N 3130 -540 3130 -530 { lab=Vg}
N 3080 -890 3080 -730 { lab=VDD}
N 2820 -540 3030 -540 { lab=Vg}
N 3080 -670 3080 -500 { lab=#net34}
N 3080 -500 3080 -360 { lab=#net34}
N 3080 -360 3280 -360 { lab=#net34}
N 3280 -360 3280 -290 { lab=#net34}
N 3180 -500 3180 -430 { lab=#net35}
N 3180 -620 3180 -500 { lab=#net35}
N 3180 -620 3280 -620 { lab=#net35}
N 3280 -730 3280 -620 { lab=#net35}
N 3380 -890 3380 -730 { lab=VDD}
N 3180 -430 3180 -380 { lab=#net35}
N 3180 -380 3380 -380 { lab=#net35}
N 3380 -380 3380 -290 { lab=#net35}
N 3480 -890 3480 -730 { lab=VDD}
N 4380 -810 4380 -730 { lab=#net32}
N 3580 -730 3580 -600 { lab=#net36}
N 3280 -600 3580 -600 { lab=#net36}
N 3280 -600 3280 -500 { lab=#net36}
N 3580 -600 3580 -500 { lab=#net36}
N 3780 -890 3780 -730 { lab=VDD}
N 3580 -500 3580 -290 { lab=#net36}
N 4280 -500 4280 -370 { lab=#net40}
N 4280 -670 4280 -500 { lab=#net40}
N 4080 -730 4080 -620 { lab=#net39}
N 4080 -620 4180 -620 { lab=#net39}
N 4180 -620 4180 -500 { lab=#net39}
N 4180 -500 4180 -430 { lab=#net39}
N 3980 -430 3980 -290 { lab=#net39}
N 3880 -580 4080 -580 { lab=#net38}
N 4080 -580 4080 -500 { lab=#net38}
N 4080 -500 4080 -390 { lab=#net38}
N 3880 -390 4080 -390 { lab=#net38}
N 3880 -390 3880 -290 { lab=#net38}
N 3680 -730 3680 -500 { lab=#net37}
N 3680 -500 3680 -430 { lab=#net37}
N 3680 -430 3680 -290 { lab=#net37}
N 3780 -500 3780 -390 { lab=#net38}
N 3780 -390 3880 -390 { lab=#net38}
N 2760 -790 2820 -790 { lab=Vg}
N 2760 -790 2760 -540 { lab=Vg}
N 2760 -540 2820 -540 { lab=Vg}
N 2780 -650 2800 -650 { lab=GND}
N 2780 -650 2780 -190 { lab=GND}
N 2780 -190 2800 -190 { lab=GND}
N 3880 -730 3880 -580 { lab=#net38}
N 2830 -760 2930 -760 { lab=GND}
N 2860 -730 2900 -730 { lab=GND}
N 2800 -760 2800 -730 { lab=GND}
N 2800 -760 2830 -760 { lab=GND}
N 2880 -760 2880 -730 { lab=GND}
N 2960 -730 3000 -730 { lab=#net34}
N 2880 -730 2880 -650 { lab=GND}
N 4460 -730 4500 -730 { lab=#net40}
N 4530 -760 4630 -760 { lab=GND}
N 4630 -760 4660 -760 { lab=GND}
N 4660 -760 4660 -730 { lab=GND}
N 4560 -730 4600 -730 { lab=GND}
N 4580 -760 4580 -730 { lab=GND}
N 4230 -650 4580 -650 { lab=GND}
N 4580 -730 4580 -650 { lab=GND}
N 2960 -500 3000 -500 { lab=#net35}
N 2830 -530 2930 -530 { lab=GND}
N 2800 -530 2830 -530 { lab=GND}
N 2800 -530 2800 -500 { lab=GND}
N 2860 -500 2900 -500 { lab=GND}
N 2880 -530 2880 -500 { lab=GND}
N 2780 -500 2800 -500 { lab=GND}
N 2860 -290 2900 -290 { lab=GND}
N 2960 -290 3000 -290 { lab=GND}
N 3060 -290 3100 -290 { lab=GND}
N 3160 -290 3200 -290 { lab=GND}
N 2800 -260 3130 -260 { lab=GND}
N 2800 -290 2800 -260 { lab=GND}
N 2880 -290 2880 -260 { lab=GND}
N 2980 -290 2980 -260 { lab=GND}
N 3080 -290 3080 -260 { lab=GND}
N 2980 -260 2980 -190 { lab=GND}
N 4180 -370 4180 -290 { lab=#net40}
N 4180 -370 4280 -370 { lab=#net40}
N 4160 -290 4200 -290 { lab=#net40}
N 4230 -260 4660 -260 { lab=GND}
N 4660 -290 4660 -260 { lab=GND}
N 4560 -290 4600 -290 { lab=GND}
N 4460 -290 4500 -290 { lab=GND}
N 4360 -290 4400 -290 { lab=GND}
N 4260 -290 4300 -290 { lab=GND}
N 4280 -290 4280 -260 { lab=GND}
N 4380 -290 4380 -260 { lab=GND}
N 4480 -290 4480 -260 { lab=GND}
N 4580 -290 4580 -260 { lab=GND}
N 4430 -260 4430 -190 { lab=GND}
N 4360 -500 4400 -500 { lab=#net39}
N 4460 -500 4500 -500 { lab=GND}
N 4560 -500 4600 -500 { lab=GND}
N 4430 -530 4660 -530 { lab=GND}
N 4660 -530 4660 -500 { lab=GND}
N 4580 -530 4580 -500 { lab=GND}
N 4480 -530 4480 -500 { lab=GND}
N 4580 -650 4580 -530 { lab=GND}
N 2760 -890 4720 -890 { lab=VDD}
N 2760 -910 2760 -890 { lab=VDD}
N 2780 -190 2780 -150 { lab=GND}
N 3980 -890 3980 -730 { lab=VDD}
N 4130 -260 4130 -190 { lab=GND}
N 4030 -260 4030 -190 { lab=GND}
N 3830 -260 3830 -190 { lab=GND}
N 3730 -260 3730 -190 { lab=GND}
N 3530 -260 3530 -190 { lab=GND}
N 3430 -260 3430 -190 { lab=GND}
N 4370 -1150 4370 -920 { lab=#net32}
N 4370 -920 4380 -920 { lab=#net32}
N 3970 -1090 4180 -1090 { lab=#net29}
N 2470 -1440 2790 -1440 { lab=#net30}
N 2790 -1440 2790 -1180 { lab=#net30}
N 2670 -1260 4570 -1260 { lab=Vout}
N 2190 -1440 2460 -1440 { lab=#net28}
N 4380 -920 4380 -810 { lab=#net32}
N 4180 -1080 4180 -730 { lab=#net29}
N 4180 -1090 4180 -1080 { lab=#net29}
N 2790 -1180 4270 -1180 { lab=#net30}
N 4780 -1690 5000 -1690 { lab=Vbn}
N 1920 -2080 1920 -2060 { lab=#net1}
N 1800 -2080 1800 -2060 { lab=#net1}
N 1680 -2080 1680 -2060 { lab=#net1}
N 1560 -2080 1560 -2060 { lab=#net1}
N 1590 -2030 1650 -2030 { lab=#net1}
N 1710 -2030 1770 -2030 { lab=Vr}
N 1830 -2030 1890 -2030 { lab=#net1}
N 1710 -2490 1770 -2490 { lab=#net2}
N 2070 -2490 2130 -2490 { lab=#net3}
N 2310 -2490 2370 -2490 { lab=#net4}
N 2670 -2490 2730 -2490 { lab=#net5}
N 2040 -2460 2040 -2440 { lab=Vdp}
N 2400 -2460 2400 -2440 { lab=Vdp}
N 2160 -2460 2160 -2440 { lab=Vdp}
N 2280 -2460 2280 -2440 { lab=Vdp}
N 1680 -2460 1680 -2410 { lab=Vbp}
N 2760 -2460 2760 -2410 { lab=Vbp}
N 2640 -2460 2640 -2410 { lab=Vbp}
N 1800 -2460 1800 -2410 { lab=Vbp}
N 1620 -2610 1620 -2490 { lab=VDD}
N 2820 -2610 2820 -2490 { lab=VDD}
N 2190 -2490 2250 -2490 { lab=VDD}
N 2220 -2610 2220 -2490 { lab=VDD}
N 2160 -2080 2160 -2060 { lab=#net1}
N 2280 -2080 2280 -2060 { lab=#net1}
N 2190 -2030 2250 -2030 { lab=#net6}
N 2550 -2030 2610 -2030 { lab=#net7}
N 2790 -2030 2850 -2030 { lab=#net8}
N 1980 -2030 1980 -1950 { lab=Vr}
N 2520 -2080 2520 -2060 { lab=#net9}
N 2880 -2080 2880 -2060 { lab=#net9}
N 2760 -2080 2760 -2060 { lab=#net9}
N 2640 -2080 2640 -2060 { lab=#net9}
N 2670 -2030 2730 -2030 { lab=GND}
N 2700 -2030 2700 -1910 { lab=GND}
N 2100 -2030 2100 -1910 { lab=GND}
N 2940 -2080 2940 -2030 { lab=#net9}
N 2460 -2410 2460 -2270 { lab=Vbp}
N 1830 -2490 1890 -2490 { lab=#net1}
N 1950 -2490 2010 -2490 { lab=Vdp}
N 1860 -2490 1860 -2320 { lab=#net1}
N 2550 -2490 2610 -2490 { lab=#net9}
N 2580 -2490 2580 -2320 { lab=#net9}
N 2430 -2490 2490 -2490 { lab=Vbp}
N 2460 -2490 2460 -2410 { lab=Vbp}
N 2070 -2030 2130 -2030 { lab=GND}
N 1950 -2030 2010 -2030 { lab=Vr}
N 2310 -2030 2370 -2030 { lab=Vdp}
N 2340 -2440 2340 -2270 { lab=Vdp}
N 2430 -2030 2490 -2030 { lab=Vbp}
N 2910 -2030 2970 -2030 { lab=#net9}
N 2790 -2490 2850 -2490 { lab=VDD}
N 2940 -2610 2940 -2490 { lab=VDD}
N 1980 -2490 1980 -2440 { lab=Vdp}
N 1980 -2440 2400 -2440 { lab=Vdp}
N 2940 -2030 2940 -1850 { lab=#net9}
N 1440 -2080 1440 -2060 { lab=GND}
N 1380 -2080 1380 -2030 { lab=GND}
N 1380 -2030 1410 -2030 { lab=GND}
N 1380 -2080 1440 -2080 { lab=GND}
N 1590 -2490 1650 -2490 { lab=VDD}
N 1560 -2460 1560 -2440 { lab=VDD}
N 1470 -2030 1530 -2030 { lab=Vr}
N 1470 -2490 1530 -2490 { lab=VDD}
N 1440 -2460 1440 -2440 { lab=VDD}
N 1440 -2440 1560 -2440 { lab=VDD}
N 1500 -2490 1500 -2440 { lab=VDD}
N 1380 -2440 1440 -2440 { lab=VDD}
N 1380 -2490 1380 -2440 { lab=VDD}
N 1380 -2490 1410 -2490 { lab=VDD}
N 2040 -2000 2040 -1910 { lab=GND}
N 1920 -2610 1920 -2520 { lab=VDD}
N 2880 -2540 2880 -2520 { lab=VDD}
N 2880 -2540 2940 -2540 { lab=VDD}
N 2520 -2610 2520 -2520 { lab=VDD}
N 2400 -2000 2400 -1910 { lab=GND}
N 1380 -2610 1380 -2490 { lab=VDD}
N 1380 -2030 1380 -1910 { lab=GND}
N 1740 -2030 1740 -1960 { lab=Vr}
N 1740 -1960 1740 -1950 { lab=Vr}
N 1860 -2080 1860 -2030 { lab=#net1}
N 1620 -2080 1620 -2030 { lab=#net1}
N 1500 -2030 1500 -1950 { lab=Vr}
N 1560 -2080 2280 -2080 { lab=#net1}
N 1290 -1950 1330 -1950 { lab=Vr}
N 2100 -2490 2100 -2390 { lab=#net3}
N 2360 -2490 2360 -2400 { lab=#net4}
N 2700 -2490 2700 -2430 { lab=#net5}
N 2220 -2030 2220 -1980 { lab=#net6}
N 2580 -2030 2580 -2000 { lab=#net7}
N 2820 -2030 2820 -2010 { lab=#net8}
N 1710 -2250 1770 -2250 { lab=#net2}
N 2070 -2250 2130 -2250 { lab=#net3}
N 2310 -2250 2370 -2250 { lab=#net4}
N 2670 -2250 2730 -2250 { lab=#net5}
N 2040 -2220 2040 -2200 { lab=Vdp}
N 2400 -2220 2400 -2200 { lab=Vdp}
N 2160 -2220 2160 -2200 { lab=Vdp}
N 2280 -2220 2280 -2200 { lab=Vdp}
N 1680 -2220 1680 -2170 { lab=Vbp}
N 2760 -2220 2760 -2170 { lab=Vbp}
N 2640 -2220 2640 -2170 { lab=Vbp}
N 1800 -2220 1800 -2170 { lab=Vbp}
N 1620 -2370 1620 -2250 { lab=VDD}
N 2820 -2370 2820 -2250 { lab=VDD}
N 2190 -2250 2250 -2250 { lab=VDD}
N 2220 -2370 2220 -2250 { lab=VDD}
N 2460 -2170 2460 -2030 { lab=Vbp}
N 1830 -2250 1890 -2250 { lab=#net1}
N 1950 -2250 2010 -2250 { lab=Vdp}
N 1860 -2250 1860 -2080 { lab=#net1}
N 2550 -2250 2610 -2250 { lab=#net9}
N 2580 -2250 2580 -2080 { lab=#net9}
N 2430 -2250 2490 -2250 { lab=Vbp}
N 2460 -2250 2460 -2170 { lab=Vbp}
N 2340 -2200 2340 -2030 { lab=Vdp}
N 2790 -2250 2850 -2250 { lab=VDD}
N 2940 -2370 2940 -2250 { lab=VDD}
N 1980 -2250 1980 -2200 { lab=Vdp}
N 1980 -2200 2400 -2200 { lab=Vdp}
N 1590 -2250 1650 -2250 { lab=VDD}
N 1560 -2220 1560 -2200 { lab=VDD}
N 1470 -2250 1530 -2250 { lab=VDD}
N 1440 -2220 1440 -2200 { lab=VDD}
N 1440 -2200 1560 -2200 { lab=VDD}
N 1500 -2250 1500 -2200 { lab=VDD}
N 1380 -2200 1440 -2200 { lab=VDD}
N 1380 -2250 1380 -2200 { lab=VDD}
N 1380 -2250 1410 -2250 { lab=VDD}
N 1920 -2370 1920 -2280 { lab=VDD}
N 2880 -2300 2880 -2280 { lab=VDD}
N 2880 -2300 2940 -2300 { lab=VDD}
N 2520 -2370 2520 -2280 { lab=VDD}
N 1380 -2370 1380 -2250 { lab=VDD}
N 2700 -2250 2700 -2190 { lab=#net5}
N 1740 -2340 1740 -2250 { lab=#net2}
N 2340 -2270 2340 -2200 { lab=Vdp}
N 1920 -2520 1920 -2370 { lab=VDD}
N 1680 -2170 1800 -2170 { lab=Vbp}
N 1330 -2370 2940 -2370 { lab=VDD}
N 1860 -2320 1860 -2250 { lab=#net1}
N 2460 -2270 2460 -2250 { lab=Vbp}
N 1800 -2170 2760 -2170 { lab=Vbp}
N 2910 -2250 2940 -2250 { lab=VDD}
N 2580 -2320 2580 -2250 { lab=#net9}
N 1330 -2610 2940 -2610 { lab=VDD}
N 2910 -2490 2940 -2490 { lab=VDD}
N 2700 -2430 2700 -2250 { lab=#net5}
N 2100 -2390 2100 -2250 { lab=#net3}
N 2360 -2400 2360 -2250 { lab=#net4}
N 1680 -2410 3010 -2410 { lab=Vbp}
N 1920 -1830 1920 -1810 { lab=#net1}
N 1800 -1830 1800 -1810 { lab=#net1}
N 1680 -1830 1680 -1810 { lab=#net1}
N 1560 -1830 1560 -1810 { lab=#net1}
N 1590 -1780 1650 -1780 { lab=#net1}
N 1710 -1780 1770 -1780 { lab=Vr}
N 1830 -1780 1890 -1780 { lab=#net1}
N 2160 -1830 2160 -1810 { lab=#net1}
N 2280 -1830 2280 -1810 { lab=#net1}
N 2190 -1780 2250 -1780 { lab=#net6}
N 2550 -1780 2610 -1780 { lab=#net7}
N 2790 -1780 2850 -1780 { lab=#net8}
N 2520 -1830 2520 -1810 { lab=#net9}
N 2880 -1830 2880 -1810 { lab=#net9}
N 2760 -1830 2760 -1810 { lab=#net9}
N 2640 -1830 2640 -1810 { lab=#net9}
N 2670 -1780 2730 -1780 { lab=GND}
N 2940 -1830 2940 -1780 { lab=#net9}
N 2070 -1780 2130 -1780 { lab=GND}
N 1950 -1780 2010 -1780 { lab=Vr}
N 2310 -1780 2370 -1780 { lab=Vdp}
N 2430 -1780 2490 -1780 { lab=Vbp}
N 1440 -1830 1440 -1810 { lab=GND}
N 1380 -1830 1380 -1780 { lab=GND}
N 1380 -1780 1410 -1780 { lab=GND}
N 1380 -1830 1440 -1830 { lab=GND}
N 1470 -1780 1530 -1780 { lab=Vr}
N 1860 -1830 1860 -1780 { lab=#net1}
N 1620 -1830 1620 -1780 { lab=#net1}
N 1560 -1830 2280 -1830 { lab=#net1}
N 2520 -1830 2880 -1830 { lab=#net9}
N 2880 -1830 2940 -1830 { lab=#net9}
N 2910 -1780 2940 -1780 { lab=#net9}
N 2940 -1850 2940 -1830 { lab=#net9}
N 2700 -1910 2700 -1780 { lab=GND}
N 2400 -1910 2400 -1810 { lab=GND}
N 2580 -2000 2580 -1780 { lab=#net7}
N 2820 -2010 2820 -1780 { lab=#net8}
N 2220 -1980 2220 -1780 { lab=#net6}
N 1740 -1950 1740 -1780 { lab=Vr}
N 1920 -2060 1920 -1830 { lab=#net1}
N 2040 -1910 2040 -1810 { lab=GND}
N 1980 -1950 1980 -1780 { lab=Vr}
N 1500 -1950 1500 -1780 { lab=Vr}
N 2100 -1910 2100 -1780 { lab=GND}
N 1800 -2060 1800 -1830 { lab=#net1}
N 1680 -2060 1680 -1830 { lab=#net1}
N 1560 -2060 1560 -1830 { lab=#net1}
N 2160 -2060 2160 -1830 { lab=#net1}
N 2280 -2060 2280 -1830 { lab=#net1}
N 2520 -2060 2520 -1830 { lab=#net9}
N 2640 -2060 2640 -1830 { lab=#net9}
N 2760 -2060 2760 -1830 { lab=#net9}
N 2880 -2060 2880 -1830 { lab=#net9}
N 3000 -2540 3000 -2530 { lab=VDD}
N 3000 -2530 3000 -2520 { lab=VDD}
N 2940 -2540 3000 -2540 { lab=VDD}
N 2940 -2490 2970 -2490 { lab=VDD}
N 2940 -2610 3030 -2610 { lab=VDD}
N 3030 -2610 3030 -2490 { lab=VDD}
N 2940 -2370 2940 -2250 { lab=VDD}
N 3000 -2300 3000 -2290 { lab=VDD}
N 3000 -2290 3000 -2280 { lab=VDD}
N 2940 -2300 3000 -2300 { lab=VDD}
N 2940 -2250 2970 -2250 { lab=VDD}
N 2940 -2370 3030 -2370 { lab=VDD}
N 3030 -2370 3030 -2250 { lab=VDD}
N 1380 -1780 1380 -1660 { lab=GND}
N 1330 -1660 1380 -1660 { lab=GND}
N 1380 -1660 2940 -1660 { lab=GND}
N 3000 -2000 3030 -2000 { lab=GND}
N 3030 -2030 3030 -2000 { lab=GND}
N 3030 -2000 3030 -1950 { lab=GND}
N 2940 -1780 2970 -1780 { lab=#net9}
N 3000 -1750 3030 -1750 { lab=GND}
N 3030 -1780 3030 -1750 { lab=GND}
N 2940 -1660 3030 -1660 { lab=GND}
N 3030 -1750 3030 -1660 { lab=GND}
N 2520 -2080 2940 -2080 { lab=#net9}
N 1330 -1910 3030 -1910 { lab=GND}
N 3030 -1950 3030 -1910 { lab=GND}
N 1330 -1950 1980 -1950 { lab=Vr}
N 1280 -1950 1290 -1950 { lab=Vr}
N 2460 -2030 2460 -1780 { lab=Vbp}
N 2340 -2030 2340 -1780 { lab=Vdp}
N 1740 -2490 1740 -2340 { lab=#net2}
N 2940 -1830 3070 -1830 {}
N 3070 -1830 3520 -1830 {}
N 3520 -1830 3520 -1690 {}
N 3010 -2410 3200 -2410 {}
C {madvlsi/tt_models.sym} 5220 -1260 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {devices/code.sym} 5230 -1030 0 0 {name=SPICE only_toplevel=false value=".control
  set wr_singlescale
  let runs = 40
  let run = 30
  while run <= runs
    set appendwrite = FALSE
    let code = 0
    while code < 128
      if code eq 0
        let b0 = 0
      else
        let b0 = (code % 2) * 1.8
      end
      if floor(code / 2) eq 0
        let b1 = 0
      else
        let b1 = (floor(code / 2) % 2) * 1.8
      end
      if floor(code / 4) eq 0
        let b2 = 0
      else
        let b2 = (floor(code / 4) % 2) * 1.8
      end
      if floor(code / 8) eq 0
        let b3 = 0
      else
        let b3 = floor(code / 8) % 2 * 1.8
      end
      if floor(code / 16) eq 0
        let b4 = 0
      else 
        let b4 = floor(code / 16) % 2 * 1.8
      end
      if floor(code / 32) eq 0
        let b5 = 0
      else
        let b5 = floor(code / 32) % 2 * 1.8
      end
      if floor(code / 64) eq 0
        let b6 = 0
      else
        let b6 = floor(code / 64) % 2 * 1.8
      end
      alter vb0 $&b0
      alter vb1 $&b1
      alter vb2 $&b2
      alter vb3 $&b3
      alter vb4 $&b4
      alter vb5 $&b5
      alter vb6 $&b6
      dc Vdd 1.75 1.85 0.005
      save v(b0) v(b1) v(b2) v(b3) v(b4) v(b5) v(b6) i(vbias) i(viout) v(vout)
      set wr_vecnames
      wrdata ~/Documents/MADVLSI-MP4/schematic/data/vdd_sweep_data/dac7_LDS_Vdd-\{$&code\}-\{$&run\}.txt v(b0) v(b1) v(b2) v(b3) v(b4) v(b5) v(b6) i(vbias) i(viout) v(vout)
      let code = code + 1
    end
    reset
    let run = run + 1
    destroy
  end
.endc"}
C {madvlsi/vsource.sym} 5280 -800 0 0 {name=Vdd
value=1.8}
C {madvlsi/gnd.sym} 5280 -770 0 0 {name=l17 lab=GND}
C {madvlsi/vdd.sym} 5280 -830 0 0 {name=l18 lab=VDD}
C {madvlsi/resistor.sym} 1220 -1920 0 0 {name=R1
value=400k
m=1}
C {madvlsi/ammeter1.sym} 1280 -1950 1 1 {name=vbias}
C {madvlsi/gnd.sym} 1220 -1890 0 0 {name=l26 lab=GND}
C {madvlsi/nmos3.sym} 4480 -1780 3 0 {name=M60
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4480 -2010 3 0 {name=M61
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4480 -2120 3 0 {name=M62
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4480 -1890 1 0 {name=M63
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 4430 -2150 0 0 {name=l14 lab=VDD}
C {madvlsi/nmos3.sym} 4880 -1780 3 0 {name=Mdumb64
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4880 -2010 3 0 {name=Mdumb65
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4880 -2120 3 0 {name=Mdumb66
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4880 -1890 3 0 {name=Mdumb67
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4380 -1780 3 0 {name=Mdumb68
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4380 -2010 3 0 {name=Mdumb69
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4380 -2120 3 0 {name=Mdumb70
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4380 -1890 3 0 {name=Mdumb71
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 4910 -1860 0 0 {name=l22 lab=GND}
C {madvlsi/gnd.sym} 4910 -1750 0 0 {name=l23 lab=GND}
C {madvlsi/gnd.sym} 4910 -2090 0 0 {name=l27 lab=GND}
C {madvlsi/gnd.sym} 4910 -1980 0 0 {name=l28 lab=GND}
C {madvlsi/gnd.sym} 4350 -1750 0 0 {name=l29 lab=GND}
C {madvlsi/gnd.sym} 4350 -1860 0 0 {name=l30 lab=GND}
C {madvlsi/gnd.sym} 4350 -1980 0 0 {name=l31 lab=GND}
C {madvlsi/gnd.sym} 4350 -2090 0 0 {name=l32 lab=GND}
C {madvlsi/nmos3.sym} 4580 -1780 3 0 {name=M59
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4580 -2010 3 0 {name=M72
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4580 -2120 3 0 {name=M73
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4580 -1890 1 0 {name=M74
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4680 -1780 3 0 {name=M75
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4680 -2010 3 0 {name=M64
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4680 -2120 3 0 {name=M65
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4680 -1890 1 0 {name=M66
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4780 -1780 3 0 {name=M67
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4780 -2010 3 0 {name=M68
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4780 -2120 3 0 {name=M69
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4780 -1890 1 0 {name=M70
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 4830 -2150 0 0 {name=l33 lab=VDD}
C {madvlsi/gnd.sym} 4830 -1780 0 0 {name=l34 lab=GND}
C {madvlsi/gnd.sym} 4430 -1780 0 0 {name=l35 lab=GND}
C {madvlsi/pmos3.sym} 3790 -2010 1 0 {name=M76
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3890 -2010 1 0 {name=M77
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3990 -2010 1 0 {name=M78
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4090 -2010 1 0 {name=M79
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3790 -2120 3 0 {name=M80
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3890 -2120 3 0 {name=M81
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3990 -2120 3 0 {name=M82
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4090 -2120 3 0 {name=M83
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 3940 -1730 0 0 {name=l36 lab=GND}
C {madvlsi/vdd.sym} 3940 -2150 0 0 {name=l37 lab=VDD}
C {madvlsi/pmos3.sym} 3690 -2010 1 0 {name=Mdumb45
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3690 -2120 1 0 {name=Mdumb46
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4190 -2010 1 0 {name=Mdumb47
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4190 -2120 1 0 {name=Mdumb48
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3690 -1890 3 0 {name=Mdumb49
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3690 -1780 3 0 {name=Mdumb84
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 3660 -1750 0 0 {name=l38 lab=GND}
C {madvlsi/gnd.sym} 3660 -1860 0 0 {name=l43 lab=GND}
C {madvlsi/vdd.sym} 3660 -2150 0 0 {name=l47 lab=VDD}
C {madvlsi/vdd.sym} 3660 -2040 0 0 {name=l51 lab=VDD}
C {madvlsi/gnd.sym} 4220 -1860 0 0 {name=l54 lab=GND}
C {madvlsi/gnd.sym} 4220 -1750 0 0 {name=l56 lab=GND}
C {madvlsi/vdd.sym} 4220 -2040 0 0 {name=l58 lab=VDD}
C {madvlsi/vdd.sym} 4220 -2150 0 0 {name=l59 lab=VDD}
C {madvlsi/nmos3.sym} 3790 -1890 3 0 {name=M51
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3790 -1780 3 0 {name=M52
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3890 -1890 3 0 {name=M53
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3890 -1780 3 0 {name=M54
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3990 -1890 3 0 {name=M55
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3990 -1780 1 0 {name=M56
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4090 -1890 3 0 {name=M57
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4090 -1780 1 0 {name=M58
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4190 -1890 3 0 {name=Mdumb85
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4190 -1780 3 0 {name=Mdumb60
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 5000 -1950 2 0 {name=l61 sig_type=std_logic lab=Vg}
C {madvlsi/capacitor.sym} 3140 -2380 0 0 {name=C1
value=10p
m=1}
C {madvlsi/gnd.sym} 3140 -2350 0 0 {name=l64 lab=GND}
C {madvlsi/nmos3.sym} 510 -1360 1 0 {name=M50
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 610 -1360 1 0 {name=M71
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 710 -1360 1 0 {name=Mdumb72
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 810 -1360 1 0 {name=M84
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 910 -1360 1 0 {name=Mdumb86
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1010 -1360 1 0 {name=M87
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1110 -1360 1 0 {name=Mdumb88
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1210 -1360 1 0 {name=M89
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1310 -1360 1 0 {name=Mdumb90
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1410 -1360 1 0 {name=M91
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1510 -1360 1 0 {name=Mdumb92
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1610 -1360 1 0 {name=M93
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1710 -1360 1 0 {name=Mdumb94
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1810 -1360 1 0 {name=M95
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1910 -1360 1 0 {name=M96
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 510 -1130 1 0 {name=M97
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 610 -1130 1 0 {name=M98
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 710 -1130 1 0 {name=M99
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 810 -1130 1 0 {name=M100
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 910 -1130 1 0 {name=Mdumb101
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1010 -1130 1 0 {name=M102
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1110 -1130 1 0 {name=M103
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1210 -1130 1 0 {name=M104
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1310 -1130 1 0 {name=M105
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1410 -1130 1 0 {name=Mdumb106
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1510 -1130 1 0 {name=M107
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1610 -1130 1 0 {name=M108
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1710 -1130 1 0 {name=M109
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1810 -1130 1 0 {name=M110
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 710 -920 3 0 {name=M111
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 810 -920 3 0 {name=Mdumb112
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 910 -920 3 0 {name=M113
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1010 -920 3 0 {name=M114
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1110 -920 3 0 {name=Mdumb115
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1210 -920 3 0 {name=M116
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1310 -920 3 0 {name=M117
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1410 -920 3 0 {name=Mdumb118
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1510 -920 3 0 {name=M119
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1610 -920 3 0 {name=M120
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2010 -1360 1 0 {name=Mdumb121
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2110 -1360 1 0 {name=Mdumb122
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 410 -1360 1 0 {name=Mdumb123
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 310 -1360 1 0 {name=Mdumb124
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 410 -1130 1 0 {name=Mdumb125
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 310 -1130 1 0 {name=Mdumb126
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1910 -1130 1 0 {name=Mdumb127
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2010 -1130 1 0 {name=Mdumb128
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2110 -1130 1 0 {name=M129
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1710 -920 3 0 {name=Mdumb130
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1810 -920 3 0 {name=Mdumb131
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1910 -920 3 0 {name=Mdumb132
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2010 -920 3 0 {name=Mdumb133
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2110 -920 3 0 {name=Mdumb134
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 610 -920 3 0 {name=Mdumb135
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 510 -920 3 0 {name=Mdumb136
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 410 -920 3 0 {name=Mdumb137
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 310 -920 3 0 {name=Mdumb138
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 2160 -1420 2 0 {name=l24 sig_type=std_logic lab=Vg}
C {madvlsi/vdd.sym} 240 -1540 0 0 {name=l25 lab=VDD}
C {madvlsi/gnd.sym} 260 -780 0 0 {name=l65 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 550 -660 3 0 {name=X1}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 760 -660 3 0 {name=X9}
C {madvlsi/gnd.sym} 570 -620 0 0 {name=l71 lab=GND}
C {madvlsi/gnd.sym} 780 -620 0 0 {name=l72 lab=GND}
C {madvlsi/vsource.sym} 810 -540 0 0 {name=Vb1
value=0}
C {madvlsi/gnd.sym} 810 -510 0 0 {name=l73 lab=GND}
C {madvlsi/gnd.sym} 1020 -510 0 0 {name=l74 lab=GND}
C {devices/lab_pin.sym} 530 -580 0 0 {name=l75 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 600 -660 2 0 {name=l76 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} 810 -660 1 0 {name=l78 sig_type=std_logic lab=s1}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 970 -660 3 0 {name=X10}
C {madvlsi/gnd.sym} 990 -620 0 0 {name=l79 lab=GND}
C {madvlsi/gnd.sym} 1210 -510 0 0 {name=l80 lab=GND}
C {devices/lab_pin.sym} 1020 -660 2 0 {name=l81 sig_type=std_logic lab=s2}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 1160 -660 3 0 {name=X11}
C {madvlsi/gnd.sym} 1180 -620 0 0 {name=l82 lab=GND}
C {madvlsi/gnd.sym} 1400 -510 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} 1210 -660 2 0 {name=l84 sig_type=std_logic lab=s3}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 1350 -660 3 0 {name=X12}
C {madvlsi/gnd.sym} 1370 -620 0 0 {name=l86 lab=GND}
C {madvlsi/gnd.sym} 1590 -510 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} 1400 -660 2 0 {name=l90 sig_type=std_logic lab=s4}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 1540 -660 3 0 {name=X13}
C {madvlsi/gnd.sym} 1560 -620 0 0 {name=l91 lab=GND}
C {madvlsi/gnd.sym} 1780 -510 0 0 {name=l92 lab=GND}
C {devices/lab_pin.sym} 1590 -660 2 0 {name=l94 sig_type=std_logic lab=s5}
C {madvlsi/vsource.sym} 600 -540 0 0 {name=Vb0
value=0}
C {/home/madvlsi/Documents/MADVLSI-MP4/schematic/mux2.sym} 1730 -660 3 0 {name=X14}
C {madvlsi/gnd.sym} 1750 -620 0 0 {name=l95 lab=GND}
C {devices/lab_pin.sym} 1780 -660 2 0 {name=l98 sig_type=std_logic lab=s6}
C {madvlsi/gnd.sym} 600 -510 0 0 {name=l99 lab=GND}
C {devices/lab_pin.sym} 710 -780 3 0 {name=l100 sig_type=std_logic lab=b0}
C {devices/lab_pin.sym} 1010 -790 3 0 {name=l102 sig_type=std_logic lab=b2}
C {devices/lab_pin.sym} 910 -790 3 0 {name=l103 sig_type=std_logic lab=b1}
C {devices/lab_pin.sym} 1510 -790 3 0 {name=l104 sig_type=std_logic lab=b5}
C {devices/lab_pin.sym} 1210 -790 3 0 {name=l105 sig_type=std_logic lab=b3}
C {devices/lab_pin.sym} 1310 -790 3 0 {name=l106 sig_type=std_logic lab=b4}
C {devices/lab_pin.sym} 1610 -790 3 0 {name=l107 sig_type=std_logic lab=b6}
C {madvlsi/pmos3.sym} 3520 -1340 3 0 {name=M140
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3620 -1340 3 0 {name=M2a
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3720 -1340 3 0 {name=M141
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3820 -1340 3 0 {name=M4a
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3920 -1340 3 0 {name=M5a
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4020 -1340 3 0 {name=M5b
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4120 -1340 3 0 {name=M4b
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4220 -1340 3 0 {name=M142
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4320 -1340 3 0 {name=M2b
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4420 -1340 3 0 {name=M143
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3420 -1340 3 0 {name=M1a
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4520 -1340 3 0 {name=M1b
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3320 -1340 3 0 {name=M144
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4620 -1340 3 0 {name=M145
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 2840 -1530 0 0 {name=l116 lab=VDD}
C {madvlsi/pmos3.sym} 4720 -1340 3 0 {name=M146
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4820 -1340 3 0 {name=M147
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3220 -1340 3 0 {name=M148
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3120 -1340 3 0 {name=M149
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3020 -1340 3 0 {name=M150
L=4
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vsource.sym} 2670 -1190 0 0 {name=Vout
value=0.8}
C {madvlsi/gnd.sym} 2670 -1130 0 0 {name=l117 lab=GND}
C {madvlsi/ammeter1.sym} 2670 -1240 0 0 {name=VIout}
C {madvlsi/nmos3.sym} 3030 -730 1 0 {name=M151
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3130 -730 1 0 {name=M152
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3230 -730 1 0 {name=Mdumb153
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3330 -730 1 0 {name=M154
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3430 -730 1 0 {name=Mdumb155
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3530 -730 1 0 {name=M156
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3630 -730 1 0 {name=Mdumb34
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3730 -730 1 0 {name=M157
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3830 -730 1 0 {name=Mdumb37
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3930 -730 1 0 {name=M158
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4030 -730 1 0 {name=Mdumb40
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4130 -730 1 0 {name=M159
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4230 -730 1 0 {name=Mdumb43
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4330 -730 1 0 {name=M160
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4430 -730 1 0 {name=M161
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3030 -500 1 0 {name=M162
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3130 -500 1 0 {name=M163
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3230 -500 1 0 {name=M164
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3330 -500 1 0 {name=M165
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3430 -500 1 0 {name=Mdumb166
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3530 -500 1 0 {name=M167
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3630 -500 1 0 {name=M168
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3730 -500 1 0 {name=M169
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3830 -500 1 0 {name=M170
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3930 -500 1 0 {name=Mdumb171
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4030 -500 1 0 {name=M172
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4130 -500 1 0 {name=M173
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4230 -500 1 0 {name=M174
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4330 -500 1 0 {name=M175
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3230 -290 3 0 {name=M176
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3330 -290 3 0 {name=Mdumb177
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3430 -290 3 0 {name=M178
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3530 -290 3 0 {name=M179
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3630 -290 3 0 {name=Mdumb180
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3730 -290 3 0 {name=M181
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3830 -290 3 0 {name=M182
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3930 -290 3 0 {name=Mdumb183
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4030 -290 3 0 {name=M184
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4130 -290 3 0 {name=M185
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4530 -730 1 0 {name=Mdumb74
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4630 -730 1 0 {name=Mdumb75
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2930 -730 1 0 {name=Mdumb76
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2830 -730 1 0 {name=Mdumb77
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2930 -500 1 0 {name=Mdumb78
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2830 -500 1 0 {name=Mdumb79
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4430 -500 1 0 {name=Mdumb80
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4530 -500 1 0 {name=Mdumb81
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4630 -500 1 0 {name=M186
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4230 -290 3 0 {name=Mdumb83
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4330 -290 3 0 {name=Mdumb187
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4430 -290 3 0 {name=Mdumb188
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4530 -290 3 0 {name=Mdumb189
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4630 -290 3 0 {name=Mdumb87
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3130 -290 3 0 {name=Mdumb190
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3030 -290 3 0 {name=Mdumb89
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2930 -290 3 0 {name=Mdumb191
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2830 -290 3 0 {name=Mdumb91
L=4
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 4680 -790 2 0 {name=l118 sig_type=std_logic lab=Vg}
C {madvlsi/vdd.sym} 2760 -910 0 0 {name=l119 lab=VDD}
C {madvlsi/gnd.sym} 2780 -150 0 0 {name=l120 lab=GND}
C {madvlsi/ammeter1.sym} 2470 -1440 1 0 {name=VIl}
C {devices/lab_pin.sym} 3230 -260 3 0 {name=l121 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 5000 -1690 2 0 {name=l1 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 2710 -1260 1 0 {name=l5 sig_type=std_logic lab=Vout}
C {madvlsi/vsource.sym} 1020 -540 0 0 {name=Vb2
value=0}
C {madvlsi/vsource.sym} 1210 -540 0 0 {name=Vb3
value=1.8}
C {madvlsi/vsource.sym} 1400 -540 0 0 {name=Vb4
value=1.8}
C {madvlsi/vsource.sym} 1590 -540 0 0 {name=Vb5
value=1.8}
C {madvlsi/vsource.sym} 1780 -540 0 0 {name=Vb6
value=1.8}
C {devices/lab_pin.sym} 3200 -2410 2 0 {name=l2 sig_type=std_logic lab=Vbp}
C {madvlsi/nmos3.sym} 1560 -2030 1 0 {name=M5
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1680 -2030 1 0 {name=M7
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1800 -2030 1 0 {name=M9
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1920 -2030 1 0 {name=M11
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2160 -2030 1 0 {name=M13
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2280 -2030 1 0 {name=M30
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2520 -2030 1 0 {name=M35
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2640 -2030 1 0 {name=M37
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2760 -2030 1 0 {name=M38
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2880 -2030 1 0 {name=M40
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1680 -2490 1 1 {name=M41
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1800 -2490 1 1 {name=M43
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2040 -2490 1 1 {name=M44
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2160 -2490 1 1 {name=M1
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2280 -2490 1 1 {name=M2
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2400 -2490 1 1 {name=M3
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2640 -2490 1 1 {name=M85
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2760 -2490 1 1 {name=M86
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1920 -2490 3 1 {name=Mdumb4
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2520 -2490 3 1 {name=Mdumb5
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2040 -2030 3 0 {name=Mdumb6
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2400 -2030 3 0 {name=Mdumb7
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2880 -2490 3 1 {name=Mdumb113
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1330 -1910 1 0 {name=l3 lab=GND}
C {madvlsi/vdd.sym} 1330 -2610 3 0 {name=l4 lab=VDD}
C {madvlsi/nmos3.sym} 1440 -2030 1 0 {name=Mdumb8
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1560 -2490 1 1 {name=Mdumb119
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1440 -2490 1 1 {name=Mdumb120
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 2340 -2440 1 0 {name=l6 sig_type=std_logic lab=Vdp}
C {madvlsi/pmos3.sym} 1680 -2250 1 1 {name=M10
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1800 -2250 1 1 {name=M88
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2040 -2250 1 1 {name=M12
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2160 -2250 1 1 {name=M90
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2280 -2250 1 1 {name=M101
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2400 -2250 1 1 {name=M14
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2640 -2250 1 1 {name=M15
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2760 -2250 1 1 {name=M112
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1920 -2250 3 1 {name=Mdumb16
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2520 -2250 3 1 {name=Mdumb17
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2880 -2250 3 1 {name=Mdumb18
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1330 -2370 3 0 {name=l11 lab=VDD}
C {madvlsi/pmos3.sym} 1560 -2250 1 1 {name=Mdumb19
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1440 -2250 1 1 {name=Mdumb20
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1560 -1780 1 0 {name=M21
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1680 -1780 1 0 {name=M22
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1800 -1780 1 0 {name=M23
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1920 -1780 1 0 {name=M106
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2160 -1780 1 0 {name=M24
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2280 -1780 1 0 {name=M25
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2520 -1780 1 0 {name=M26
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2640 -1780 1 0 {name=M27
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2760 -1780 1 0 {name=M28
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2880 -1780 1 0 {name=M29
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2040 -1780 1 0 {name=Mdumb30
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2400 -1780 1 0 {name=Mdumb116
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1330 -1660 1 0 {name=l15 lab=GND}
C {madvlsi/nmos3.sym} 1440 -1780 1 0 {name=Mdumb31
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3000 -2490 3 1 {name=Mdumb1
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3000 -2250 3 1 {name=Mdumb2
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3000 -1780 3 0 {name=Mdumb3
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3000 -2030 3 0 {name=Mdumb32
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
